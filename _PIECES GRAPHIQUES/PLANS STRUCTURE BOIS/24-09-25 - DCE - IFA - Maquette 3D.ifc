Properties of the parts of a building model (IFC4), part 1 of 4

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Architecture]
Time: 2024-09-13T11:37:09
Made in: cadwork version 30.0 build 463

# IfcSite
RefElevation: 0 m

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcBeam (1118)
In: Storey 1
Name | PredefinedType | Material | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | NetSurfaceArea (m2) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg) | Group | Repérage ensemble | Bâtiment | Niveaux
Poutre-028 | BEAM | Béton | 2.6 | 0.0007 | 7.6 | 7.6 | 1.092 | 1.092 | 2620.8 | 2620.8 | Béton maquette archi | 0 STR BETON
9 x Entretoise | BEAM | GL24h | 0.815 | 0.0003 | 0.7486 | 0.7486 | 0.0261 | 0.0261 | 9.9104 | 9.9104 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Ent
Poutre | BEAM | GL24h | 3.725 | 0.0006 | 5.7146 | 5.7146 | 0.3755 | 0.3755 | 142.683 | 142.683 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
Mur FOB | BEAM | MOB Paille | 20.326 | 0.0004 | 143.468 | 143.468 | 26.0254 | 23.8545 | 650.635 | 596.363 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+2
Poutre-030 | BEAM | Béton | 24.9189 | 0.001 | 91.3081 | 91.3081 | 19.9351 | 19.9351 | 47844.3 | 47844.3 | Béton maquette archi | 0 STR BETON
Mur FOB | BEAM | MOB Paille | 25.743 | 0.0004 | 181.221 | 181.221 | 40.952 | 26.6388 | 1023.8 | 665.97 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+2
4 x Poutre | BEAM | GL24h | 3.62 | 0.0004 | 4.0392 | 4.0392 | 0.2346 | 0.2346 | 89.1389 | 89.1389 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
4 x Poutre | BEAM | GL24h | 8.1 | 0.0008 | 17.944 | 17.944 | 1.8144 | 1.8144 | 689.472 | 689.472 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-013 | BEAM | Béton | 4.44 | 0.003 | 26.1492 | 26.1492 | 2.664 | 2.2317 | 6393.6 | 5356.13 | Béton maquette archi | 0 STR BETON
46 x Nervure | BEAM | GL24h | 8.02 | 0.0005 | 10.3128 | 10.3128 | 0.6159 | 0.6074 | 234.056 | 230.821 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
75 x Nervure | BEAM | GL24h | 8.34 | 0.0005 | 10.7224 | 10.7224 | 0.6405 | 0.632 | 243.395 | 240.16 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+2
20 x Poutre | BEAM | GL24h | 3.9 | 0.0006 | 5.9736 | 5.9736 | 0.3931 | 0.3931 | 149.386 | 149.386 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
18 x Poutre | BEAM | GL24h | 3.9 | 0.0006 | 5.6168 | 5.6168 | 0.3058 | 0.3058 | 116.189 | 116.189 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-013 | BEAM | Béton | 5.8617 | 0.0027 | 31.6113 | 31.6113 | 3.1653 | 2.7331 | 7596.82 | 6559.35 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 2.3045 | 0.0009 | 8.6345 | 8.6345 | 1.4519 | 1.4519 | 3484.46 | 3484.46 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 6.451 | 0.0008 | 19.0228 | 19.0228 | 3.0965 | 3.0965 | 7431.56 | 7431.56 | Béton maquette archi | 0 STR BETON
M_Ext-014 | BEAM | Béton | 4.88 | 0.0025 | 26.517 | 26.517 | 2.3912 | 2.3422 | 5738.88 | 5621.28 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 2.7586 | 0.0025 | 15.6013 | 15.6013 | 2.0276 | 1.8071 | 4866.19 | 4337.02 | Béton maquette archi | 0 STR BETON
4 x Poutre | BEAM | GL24h | 2.43 | 0.0004 | 2.754 | 2.754 | 0.1575 | 0.1575 | 59.8363 | 59.8363 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Lisse de chainage | BEAM | GL24h | 23.52 | 0.0004 | 19.8 | 19.8 | 0.508 | 0.508 | 193.052 | 193.052 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
Limon | BEAM | Acier S235 | 0.2201 | 0.0001 | 0.1368 | 0.1368 | 0.0025 | 0.0006 | 19.8568 | 4.946 | Escalier | C1 Escalier | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Lim; Sous zone: Ruche
5 x Poutre | BEAM | GL24h | 3.78 | 0.0006 | 5.4488 | 5.4488 | 0.2964 | 0.2964 | 112.614 | 112.614 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
9 x Entretoise | BEAM | GL24h | 0.815 | 0.0003 | 0.6754 | 0.6754 | 0.0228 | 0.0228 | 8.6716 | 8.6716 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Ent
Nervure | BEAM | GL24h | 1.2653 | 0.0005 | 1.4939 | 1.4939 | 0.0972 | 0.0715 | 36.9262 | 27.1519 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
28 x Nervure | BEAM | GL24h | 8.02 | 0.0005 | 10.3744 | 10.3744 | 0.6159 | 0.6124 | 234.055 | 232.694 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
Poutre-027 | BEAM | Béton | 6.1523 | 0.0007 | 18.2064 | 18.2064 | 3.0146 | 3.0146 | 7235.09 | 7235.09 | Béton maquette archi | 0 STR BETON
20 x Poutre | BEAM | GL24h | 3.9 | 0.0005 | 5.2936 | 5.2936 | 0.2839 | 0.2839 | 107.89 | 107.89 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr
3 x Support mur rideau | BEAM | GL24h | 0.8 | 0.0003 | 0.7504 | 0.7504 | 0.0314 | 0.0314 | 11.9168 | 11.9168 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
M_Ext-012 | BEAM | Béton | 37.9244 | 0.0028 | 235.466 | 235.466 | 31.7427 | 31.6171 | 76182.4 | 75881.1 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 6.707 | 0.003 | 44.1247 | 44.1247 | 4.0242 | 4.0242 | 9658.06 | 9658.06 | Béton maquette archi | 0 STR BETON
3 x Lièrne BLC | BEAM | GL24h | 3.78 | 0.0002 | 2.6264 | 2.6264 | 0.1058 | 0.1058 | 40.2192 | 40.2192 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Li
Béton | BEAM | Béton | 6.5286 | 0.0012 | 18.5336 | 18.5336 | 1.5669 | 1.5424 | 3760.47 | 3701.84 | Béton maquette archi | 0 STR BETON
10 x Nervure | BEAM | GL24h | 8.02 | 0.0005 | 10.3744 | 10.3744 | 0.6159 | 0.6124 | 234.055 | 232.694 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+0
69 x Nervure | BEAM | GL24h | 8.34 | 0.0005 | 10.7224 | 10.7224 | 0.6405 | 0.632 | 243.395 | 240.16 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+1
15 x Nervure | BEAM | GL24h | 8.02 | 0.0005 | 10.3744 | 10.3744 | 0.6159 | 0.6124 | 234.056 | 232.694 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
M_Ext-012 | BEAM | Béton | 5.24 | 0.001 | 12.8949 | 12.8949 | 1.0554 | 1.0353 | 2532.98 | 2484.64 | Béton maquette archi | 0 STR BETON
18 x Poutre | BEAM | GL24h | 3.9 | 0.0006 | 5.9736 | 5.9736 | 0.3931 | 0.3931 | 149.386 | 149.386 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
21 x Lièrne BLC | BEAM | GL24h | 3.66 | 0.0002 | 2.5448 | 2.5448 | 0.1025 | 0.1025 | 38.9424 | 38.9424 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Li
Poutre-027 | BEAM | Béton | 7.9949 | 0.0006 | 18.1888 | 18.1888 | 2.3985 | 2.3985 | 5756.32 | 5756.32 | Béton maquette archi | 0 STR BETON
4 x Poutre | BEAM | GL24h | 8.1 | 0.0009 | 19.62 | 19.62 | 2.0412 | 2.0412 | 775.656 | 775.656 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-017 | BEAM | Béton | 5.0688 | 0.0025 | 24.0509 | 24.0509 | 2.4837 | 2.0024 | 5960.94 | 4805.87 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 10.4875 | 0.0006 | 25.89 | 25.89 | 3.7755 | 3.7755 | 9061.2 | 9061.2 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 4.095 | 0.0029 | 15.5789 | 15.5789 | 2.3751 | 1.1069 | 5700.24 | 2656.53 | Béton maquette archi | 0 STR BETON
20 x Poutre | BEAM | GL24h | 3.9 | 0.0006 | 5.6168 | 5.6168 | 0.3058 | 0.3058 | 116.189 | 116.189 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-015 | BEAM | Béton | 4.02 | 0.0029 | 17.5922 | 17.5922 | 2.3316 | 1.37 | 5595.84 | 3288.08 | Béton maquette archi | 0 STR BETON
7 x Nervure | BEAM | GL24h | 8.02 | 0.0005 | 10.3128 | 10.3128 | 0.6159 | 0.6074 | 234.056 | 230.821 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+1
Poutre-027 | BEAM | Béton | 10.5009 | 0.0007 | 28.1424 | 28.1424 | 4.4104 | 4.4104 | 10584.9 | 10584.9 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 3.38 | 0.0003 | 3.3472 | 3.3472 | 0.1731 | 0.1731 | 65.7613 | 65.7613 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-012 | BEAM | Béton | 5.3 | 0.0014 | 17.3734 | 17.3734 | 1.4946 | 1.4523 | 3587.04 | 3485.52 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 3.9755 | 0.003 | 22.7852 | 22.7852 | 2.3853 | 1.893 | 5724.78 | 4543.31 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 11.005 | 0.0027 | 64.5527 | 64.5527 | 5.9427 | 5.8887 | 14262.5 | 14132.9 | Béton maquette archi | 0 STR BETON
Nervure | BEAM | GL24h | 4.6515 | 0.0005 | 5.927 | 5.927 | 0.3572 | 0.3394 | 135.75 | 128.978 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
M_Ext-012 | BEAM | Béton | 4.8195 | 0.0004 | 5.4661 | 5.4661 | 0.3397 | 0.3397 | 815.357 | 815.357 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.659 | 0.0007 | 15.5533 | 15.5533 | 2.3768 | 2.3768 | 5704.23 | 5704.23 | Béton maquette archi | 0 STR BETON
8 x Poutre | BEAM | GL24h | 8.1 | 0.0004 | 8.2588 | 8.2588 | 0.4666 | 0.4453 | 177.293 | 169.199 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+4 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
8 x Arbalétrier | BEAM | GL24h | 1.28 | 0.0003 | 1.3368 | 1.3368 | 0.0691 | 0.0691 | 26.2656 | 26.2656 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+4 | Cadwork3dProperties - Nom export 2d: Arb; Sous zone: Ruche
M_Ext-013 | BEAM | Béton | 5.032 | 0.0025 | 27.6496 | 27.6496 | 2.4657 | 2.4657 | 5917.63 | 5917.63 | Béton maquette archi | 0 STR BETON
Nervure | BEAM | GL24h | 6.6175 | 0.0005 | 8.4434 | 8.4434 | 0.5082 | 0.4904 | 193.124 | 186.352 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
M_Ext-012 | BEAM | Béton | 4.9571 | 0.0025 | 20.2177 | 20.2177 | 2.429 | 1.5676 | 5829.58 | 3762.12 | Béton maquette archi | 0 STR BETON
M_Ext-014 | BEAM | Béton | 4.2803 | 0.0032 | 24.8911 | 24.8911 | 2.7394 | 2.1674 | 6574.55 | 5201.72 | Béton maquette archi | 0 STR BETON
3 x Poutre |  | Acier S235 | 8.34 | 0.0003 | 8.0855 | 8.0855 | 0.0472 | 0.0472 | 370.296 | 370.657 | Charpente metallique |  | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-018 | BEAM | Béton | 8.6573 | 0.0025 | 42.7091 | 42.7091 | 4.3286 | 3.7183 | 10388.7 | 8923.9 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 9.3 | 0.0008 | 24.98 | 24.98 | 3.72 | 3.72 | 8928 | 8928 | Béton maquette archi | 0 STR BETON
Poutre-028 | BEAM | Béton | 6.5349 | 0.0009 | 23.6588 | 23.6588 | 4.7052 | 4.7052 | 11292.4 | 11292.4 | Béton maquette archi | 0 STR BETON
5 x Poutre | BEAM | GL24h | 8.1 | 0.0009 | 19.62 | 19.62 | 2.0412 | 2.0412 | 775.656 | 775.656 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
2 x Poutre | BEAM | GL24h | 4.31 | 0.0004 | 4.7844 | 4.7844 | 0.2793 | 0.2793 | 106.129 | 106.129 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
3 x Poutre |  | Acier S235 | 8.34 | 0.0003 | 8.0855 | 8.0855 | 0.0472 | 0.0472 | 370.296 | 370.657 | Charpente metallique |  | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
2 x Poutre | BEAM | GL24h | 3.88 | 0.0006 | 6.232 | 6.232 | 0.3476 | 0.3476 | 132.106 | 132.106 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Limon | BEAM | Acier S235 | 2.3327 | 0.0004 | 4.9966 | 4.9966 | 0.0268 | 0.0251 | 210.408 | 196.853 | Escalier | C1 Escalier | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Lim; Sous zone: Ruche
2 x Mur FOB | BEAM | MOB Paille | 3.97 | 0.0002 | 12.974 | 12.974 | 0.9615 | 0.9615 | 24.0384 | 24.0384 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+4
4 x Poutre | BEAM | GL24h | 3.78 | 0.0006 | 5.796 | 5.796 | 0.381 | 0.381 | 144.789 | 144.789 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
4 x Poutre | BEAM | GL24h | 8.1 | 0.0008 | 17.944 | 17.944 | 1.8144 | 1.8144 | 689.472 | 689.472 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-013 | BEAM | Béton | 7.107 | 0.0032 | 48.7777 | 48.7777 | 4.5485 | 4.4205 | 10916.3 | 10609.1 | Béton maquette archi | 0 STR BETON
Poutre acrotère | BEAM | GL24h | 2.59 | 0.0008 | 5.6314 | 5.6314 | 0.3954 | 0.3954 | 150.264 | 150.264 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Complement | BEAM | GL24h | 2.745 | 0.0001 | 1.4594 | 1.4594 | 0.0439 | 0.0439 | 16.6896 | 16.6896 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Sous zone: Ruche
Complement | BEAM | GL24h | 5.5 | 0.0001 | 2.892 | 2.892 | 0.088 | 0.088 | 33.44 | 33.44 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Sous zone: Ruche
M_Ext-013 | BEAM | Béton | 4.2834 | 0.0021 | 20.1362 | 20.1362 | 1.8152 | 1.7304 | 4356.44 | 4153.03 | Béton maquette archi | 0 STR BETON
MUR_EXT-028 | BEAM | Béton | 8.66 | 0.0029 | 54.4722 | 54.4722 | 5.0228 | 4.9648 | 12054.7 | 11915.5 | Béton maquette archi | 0 STR BETON
8 x Poutre | BEAM | GL24h | 8.1 | 0.0008 | 17.944 | 17.944 | 1.8144 | 1.8144 | 689.472 | 689.472 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
2 x Poutre | BEAM | GL24h | 4.31 | 0.0004 | 4.7844 | 4.7844 | 0.2793 | 0.2793 | 106.129 | 106.129 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-017 | BEAM | Béton | 4.31 | 0.0025 | 23.6082 | 23.6082 | 2.155 | 2.055 | 5172 | 4932 | Béton maquette archi | 0 STR BETON
14 x Mur FOB | BEAM | MOB Paille | 3.97 | 0.0002 | 6.3452 | 6.3452 | 0.4121 | 0.4121 | 10.3022 | 10.3022 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+4
4 x Poutre | BEAM | GL24h | 3.78 | 0.0006 | 5.796 | 5.796 | 0.381 | 0.381 | 144.789 | 144.789 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-012 | BEAM | Béton | 2.5 | 0.0024 | 8.189 | 8.189 | 1.1992 | 0.623 | 2878.12 | 1495.27 | Béton maquette archi | 0 STR BETON
2 x Poutre | BEAM | GL24h | 3.88 | 0.0005 | 5.2614 | 5.2614 | 0.3568 | 0.3324 | 135.573 | 126.305 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
21 x Nervure | BEAM | GL24h | 8.06 | 0.0005 | 10.4704 | 10.4704 | 0.619 | 0.619 | 235.223 | 235.223 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+2
9 x M_Ext-030 | BEAM | Béton | 1.2 | 0.0008 | 2.6985 | 2.6985 | 0.306 | 0.2567 | 734.4 | 616.106 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 46.8469 | 0.003 | 309.22 | 309.22 | 42.0216 | 41.8548 | 100852 | 100452 | Béton maquette archi | 0 STR BETON
Poutre-028 | BEAM | Béton | 6.5349 | 0.001 | 23.6188 | 23.6188 | 4.5745 | 4.544 | 10978.7 | 10905.6 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 6.0161 | 0.0032 | 37.8014 | 37.8014 | 3.8503 | 3.258 | 9240.69 | 7819.22 | Béton maquette archi | 0 STR BETON
8 x Poutre | BEAM | GL24h | 4 | 0.0006 | 6.456 | 6.456 | 0.432 | 0.432 | 164.16 | 164.16 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
20 x Poutre | BEAM | GL24h | 3.9 | 0.0005 | 5.6472 | 5.6472 | 0.365 | 0.365 | 138.715 | 138.715 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr
2 x Membrure | BEAM | GL28h | 9.8462 | 0.0006 | 18.5009 | 18.5009 | 1.8905 | 1.8905 | 775.089 | 775.089 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Limon | BEAM | Acier S235 | 2.4528 | 0.0004 | 5.2628 | 5.2628 | 0.0282 | 0.0264 | 221.245 | 207.398 | Escalier | C1 Escalier | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Lim; Sous zone: Ruche
M_Ext-012 | BEAM | Béton | 3.3161 | 0.0025 | 15.0884 | 15.0884 | 1.6249 | 1.1926 | 3899.7 | 2862.23 | Béton maquette archi | 0 STR BETON
Mur FOB | BEAM | MOB Paille | 20.326 | 0.0004 | 198.875 | 198.875 | 36.2779 | 34.107 | 906.946 | 852.674 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+1
Membrure | BEAM | GL28h | 7.985 | 0.0006 | 14.412 | 14.412 | 1.4309 | 1.4309 | 586.672 | 586.672 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
2 x Poutre-027 | BEAM | Béton | 10.605 | 0.0006 | 21.69 | 21.69 | 2.5452 | 2.5452 | 6108.48 | 6108.48 | Béton maquette archi | 0 STR BETON
4 x Membrure | BEAM | GL28h | 4.11 | 0.0006 | 7.592 | 7.592 | 0.7365 | 0.7365 | 301.97 | 301.97 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Mur FOB | BEAM | MOB Paille | 23.52 | 0.0004 | 142.996 | 142.996 | 30.115 | 19.639 | 752.875 | 490.975 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+2
Poutre-027 | BEAM | Béton | 12.3688 | 0.0007 | 32.9988 | 32.9988 | 5.1949 | 5.1949 | 12467.7 | 12467.7 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 8.997 | 0.0008 | 20.8844 | 20.8844 | 2.3608 | 2.3395 | 967.932 | 959.176 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
M_Ext-013 | BEAM | Béton | 6.5295 | 0.003 | 35.7686 | 35.7686 | 3.9177 | 3.0245 | 9402.42 | 7258.77 | Béton maquette archi | 0 STR BETON
Lisse de chainage | BEAM | GL24h | 21.2118 | 0.0004 | 17.7869 | 17.7869 | 0.4582 | 0.4562 | 174.107 | 173.355 | MOB/FOB | A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
Poutre-027 | BEAM | Béton | 13.751 | 0.0007 | 36.5926 | 36.5926 | 5.7754 | 5.7754 | 13861 | 13861 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 12.3039 | 0.0027 | 49.2729 | 49.2729 | 52.9491 | 4.3229 | 127078 | 10375 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 2.1411 | 0.0004 | 2.2419 | 2.2419 | 0.1079 | 0.1079 | 41.0059 | 41.0059 | Charpente L.C. | 2 A2 Salles | Bât A Autre Bâtiment | R+0
M_Ext-012 | BEAM | Béton | 21.8225 | 0.0032 | 149.258 | 149.258 | 13.9664 | 13.9024 | 33519.3 | 33365.7 | Béton maquette archi | 0 STR BETON
Nervure | BEAM | GL24h | 4.8884 | 0.0005 | 6.2796 | 6.2796 | 0.3754 | 0.3616 | 142.662 | 137.391 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
Béton | BEAM | Béton | 3.7629 | 0.0029 | 23.7577 | 23.7577 | 2.1825 | 2.0574 | 5237.99 | 4937.69 | Béton maquette archi | 0 STR BETON
4 x Poutre | BEAM | GL24h | 3.78 | 0.0006 | 5.4488 | 5.4488 | 0.2964 | 0.2964 | 112.614 | 112.614 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre-027 | BEAM | Béton | 8.4491 | 0.0008 | 26.4673 | 26.4673 | 4.7315 | 4.7315 | 11355.6 | 11355.6 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 12.4999 | 0.0007 | 33.3397 | 33.3397 | 5.25 | 5.25 | 12599.9 | 12599.9 | Béton maquette archi | 0 STR BETON
Lisse basse | BEAM | GL24h | 20.326 | 0.0003 | 20.4412 | 20.4412 | 1.1708 | 1.1708 | 444.896 | 444.896 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
12 x Support mur rideau | BEAM | GL24h | 0.82 | 0.0003 | 0.7672 | 0.7672 | 0.0321 | 0.0321 | 12.2147 | 12.2147 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
Poutre-027 | BEAM | Béton | 10.0003 | 0.001 | 33.2011 | 33.2011 | 6.0002 | 6.0002 | 14400.5 | 14400.5 | Béton maquette archi | 0 STR BETON
9 x Entretoise | BEAM | GL24h | 0.815 | 0.0003 | 0.7486 | 0.7486 | 0.0261 | 0.0261 | 9.9104 | 9.9104 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Ent
Poutre-027 | BEAM | Béton | 5.25 | 0.0009 | 18.06 | 18.06 | 3.3075 | 3.3075 | 7938 | 7938 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 2.715 | 0.0004 | 3.1848 | 3.1848 | 0.1955 | 0.1955 | 74.2824 | 74.2824 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 4.3373 | 0.0006 | 6.924 | 6.924 | 0.4684 | 0.4635 | 178.004 | 176.125 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-013 | BEAM | Béton | 4.62 | 0.001 | 11.1306 | 11.1306 | 0.8897 | 0.8897 | 2135.38 | 2135.38 | Béton maquette archi | 0 STR BETON
Nervure | BEAM | GL24h | 8.06 | 0.0005 | 10.4172 | 10.4172 | 0.619 | 0.6148 | 235.223 | 233.606 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+1
6 x M_Ext-030 | BEAM | Béton | 1.52 | 0.0007 | 3.2473 | 3.2473 | 0.3669 | 0.3176 | 880.627 | 762.333 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 4.9464 | 0.0012 | 16.685 | 16.685 | 7.4442 | 1.92 | 17866 | 4607.89 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 2.4373 | 0.0006 | 3.9367 | 3.9367 | 0.2184 | 0.2152 | 82.9852 | 81.7716 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Nervure | BEAM | GL24h | 6.8543 | 0.0005 | 8.796 | 8.796 | 0.5264 | 0.5125 | 200.036 | 194.765 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
M_Ext-012 | BEAM | Béton | 19.3998 | 0.0025 | 103.799 | 103.799 | 9.5059 | 9.5059 | 22814.1 | 22814.1 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 6.5365 | 0.003 | 43.4405 | 43.4405 | 5.7848 | 5.6203 | 13883.6 | 13488.6 | Béton maquette archi | 0 STR BETON
4 x Membrure | BEAM | GL28h | 11.5385 | 0.0006 | 20.6661 | 20.6661 | 2.0677 | 2.0677 | 847.754 | 847.754 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Poutre | BEAM | GL24h | 2.19 | 0.0005 | 3.384 | 3.384 | 0.2523 | 0.2523 | 95.8694 | 95.8694 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
Poutre-027 | BEAM | Béton | 13.694 | 0.0007 | 36.4444 | 36.4444 | 5.7515 | 5.7515 | 13803.5 | 13803.5 | Béton maquette archi | 0 STR BETON
Complement | BEAM | GL24h | 5.76 | 0.0001 | 3.0272 | 3.0272 | 0.0922 | 0.0922 | 35.0208 | 35.0208 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Sous zone: Ruche
4 x Poutre | BEAM | GL24h | 8.06 | 0.0005 | 11.8368 | 11.8368 | 0.9285 | 0.9285 | 352.835 | 352.835 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
Lisse basse | BEAM | GL24h | 23.52 | 0.0003 | 23.6352 | 23.6352 | 1.3548 | 1.3548 | 514.806 | 514.806 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Nervure | BEAM | GL24h | 2.6856 | 0.0005 | 3.4106 | 3.4106 | 0.2063 | 0.1884 | 78.3766 | 71.6038 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
Poutre-027 | BEAM | Béton | 4.6963 | 0.0009 | 16.288 | 16.288 | 2.9586 | 2.9586 | 7100.74 | 7100.74 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 11.3002 | 0.0009 | 37.4207 | 37.4207 | 7.1191 | 7.1191 | 17085.9 | 17085.9 | Béton maquette archi | 0 STR BETON
3 x Poutre |  | Acier S235 | 8.34 | 0.0003 | 8.0855 | 8.0855 | 0.0472 | 0.0472 | 370.296 | 370.657 | Charpente metallique |  | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
2 x Poutre | BEAM | Acier S235 | 8.06 | 0.0003 | 13.9869 | 13.9869 | 0.1201 | 0.1202 | 943.02 | 943.23 | Charpente metallique | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Limon | BEAM | Acier S235 | 0.0528 | 0.0001 | 0.049 | 0.049 | 0.0006 | 0.0002 | 4.7646 | 1.5947 | Escalier | C1 Escalier | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Lim; Sous zone: Ruche
2 x Poutre | BEAM | Acier S235 | 5.42 | 0.0003 | 8.7066 | 8.7066 | 0.0527 | 0.0527 | 414.088 | 413.831 | Charpente metallique | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Lièrne BLC | BEAM | GL24h | 14.5188 | 0.0002 | 9.8503 | 9.8503 | 0.4065 | 0.3854 | 154.48 | 146.44 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Li
4 x Poutre | BEAM | GL24h | 4.02 | 0.0005 | 5.8152 | 5.8152 | 0.3763 | 0.3763 | 142.983 | 142.983 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-011 | BEAM | Béton | 5.126 | 0.0017 | 21.5708 | 21.5708 | 2.6209 | 2.6209 | 6290.14 | 6290.14 | Béton maquette archi | 0 STR BETON
Limon | BEAM | Acier S235 | 0.1428 | 0.0004 | 0.2257 | 0.2257 | 0.0016 | 0.001 | 12.8826 | 8.0166 | Escalier | C1 Escalier | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Lim; Sous zone: Ruche
M_Ext-011 | BEAM | Béton | 40.1679 | 0.0028 | 237.891 | 237.891 | 33.6205 | 31.7852 | 80689.3 | 76284.5 | Béton maquette archi | 0 STR BETON
Nervure | BEAM | GL24h | 0.9565 | 0.0005 | 1.2468 | 1.2468 | 0.0735 | 0.0596 | 27.9145 | 22.6436 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
Muraillère sur beton | BEAM | GL24h | 8.02 | 0.0005 | 10.3744 | 10.3744 | 0.6159 | 0.6124 | 234.055 | 232.694 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Mu
M_Ext-011 | BEAM | Béton | 46.8469 | 0.0025 | 258.43 | 258.43 | 34.4324 | 34.2958 | 82637.9 | 82309.8 | Béton maquette archi | 0 STR BETON
2 x Limon | BEAM | Acier S235 | 0.1093 | 0 | 0.0442 | 0.0442 | 0.0013 | 0.0002 | 9.8579 | 1.5026 | Escalier | C1 Escalier | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Lim; Sous zone: Ruche
Poutre | BEAM | Acier S235 | 2.675 | 0.0003 | 4.3069 | 4.3069 | 0.026 | 0.026 | 204.37 | 204.243 | Charpente metallique | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-015 | BEAM | Béton | 3.8195 | 0.0025 | 21.2234 | 21.2234 | 1.8716 | 1.8716 | 4491.75 | 4491.75 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 5.42 | 0.0029 | 27.8304 | 27.8304 | 3.1436 | 2.279 | 7544.64 | 5469.7 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 4.8 | 0.0032 | 33.92 | 33.92 | 3.072 | 3.072 | 7372.8 | 7372.8 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 2.59 | 0.0005 | 3.7144 | 3.7144 | 0.2486 | 0.2486 | 94.4832 | 94.4832 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Pr
4 x Poutre | BEAM | GL24h | 4.02 | 0.0005 | 5.452 | 5.452 | 0.2927 | 0.2927 | 111.209 | 111.209 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Complement | BEAM | GL24h | 0.19 | 0.0001 | 0.1308 | 0.1308 | 0.003 | 0.003 | 1.1552 | 1.1552 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Sous zone: Ruche
M_Ext-012 | BEAM | Béton | 3.9161 | 0.0025 | 14.8016 | 14.8016 | 1.9189 | 1.0543 | 4605.3 | 2530.36 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 11.3521 | 0.0007 | 25.5346 | 25.5346 | 3.1786 | 3.1786 | 7628.61 | 7628.61 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 2.52 | 0.0022 | 7.5789 | 7.5789 | 1.1088 | 0.4906 | 2661.12 | 1177.51 | Béton maquette archi | 0 STR BETON
6 x Support mur rideau | BEAM | GL24h | 0.22 | 0.0003 | 0.2632 | 0.2632 | 0.0086 | 0.0086 | 3.2771 | 3.2771 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
Poutre-027 | BEAM | Béton | 5.4998 | 0.0011 | 21.3017 | 21.3017 | 4.2348 | 3.7317 | 10163.6 | 8956.11 | Béton maquette archi | 0 STR BETON
M_Ext-014 | BEAM | Béton | 10.805 | 0.0032 | 67.4055 | 67.4055 | 6.9152 | 5.9866 | 16596.5 | 14367.9 | Béton maquette archi | 0 STR BETON
Lisse de chainage | BEAM | GL24h | 43.856 | 0.0004 | 36.8822 | 36.8822 | 0.9473 | 0.9473 | 359.97 | 359.97 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
Nervure | BEAM | GL24h | 2.9224 | 0.0005 | 3.7632 | 3.7632 | 0.2244 | 0.2106 | 85.2884 | 80.0175 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0
Poutre | BEAM | GL24h | 8.02 | 0.0007 | 14.3872 | 14.3872 | 1.0907 | 1.0907 | 414.474 | 414.474 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Pr
19 x Nervure | BEAM | GL24h | 8.06 | 0.0005 | 10.4704 | 10.4704 | 0.619 | 0.619 | 235.223 | 235.223 | Plancher CLT nervure | A4 Plancher CLT nervuré | Bât A Autre Bâtiment | R+1
Poutre | BEAM | GL24h | 5.42 | 0.0007 | 10.7872 | 10.7872 | 1.032 | 1.032 | 392.148 | 392.148 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Mur FOB | BEAM | MOB Paille | 3.3 | 0.0004 | 6.7834 | 6.7834 | 0.733 | 0.733 | 18.3249 | 18.3249 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+2
Support mur rideau | BEAM | GL24h | 8.02 | 0.0004 | 8.1208 | 8.1208 | 0.4042 | 0.4042 | 153.599 | 153.599 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
M_Ext-017 | BEAM | Béton | 10.2111 | 0.0025 | 49.0869 | 49.0869 | 5.1055 | 4.3355 | 12253.3 | 10405.3 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 1.1877 | 0.0006 | 2.3374 | 2.3374 | 0.228 | 0.2019 | 93.4985 | 82.764 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Me
2 x Poutre | BEAM | GL24h | 3.88 | 0.0006 | 5.8285 | 5.8285 | 0.4055 | 0.3812 | 154.108 | 144.84 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-012 | BEAM | Béton | 3.8161 | 0.0025 | 17.0097 | 17.0097 | 1.8699 | 1.3151 | 4487.7 | 3156.23 | Béton maquette archi | 0 STR BETON
2 x Poutre | BEAM | GL24h | 2.15 | 0.0004 | 2.4516 | 2.4516 | 0.1393 | 0.1393 | 52.9416 | 52.9416 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Lisse basse | BEAM | GL24h | 16.108 | 0.0003 | 16.2232 | 16.2232 | 0.9278 | 0.9278 | 352.572 | 352.572 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
M_Ext-011 | BEAM | Béton | 2.8223 | 0.0004 | 3.6307 | 3.6307 | 0.2336 | 0.2336 | 560.693 | 560.693 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 11.25 | 0.0006 | 19.188 | 19.188 | 1.62 | 1.62 | 615.6 | 615.6 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-016 | BEAM | Béton | 2.8041 | 0.0025 | 15.7284 | 15.7284 | 1.374 | 1.3622 | 3297.59 | 3269.39 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 18.6142 | 0.0009 | 60.8253 | 60.8253 | 11.7269 | 11.7269 | 28144.6 | 28144.6 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 12.6681 | 0.0006 | 22.5329 | 22.5329 | 2.2701 | 2.2555 | 930.753 | 924.773 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Poutre | BEAM | GL24h | 8.02 | 0.0005 | 11.7792 | 11.7792 | 0.9239 | 0.9239 | 351.084 | 351.084 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-012 | BEAM | Béton | 40.1699 | 0.0025 | 221.884 | 221.884 | 29.5249 | 29.4146 | 70859.7 | 70595.1 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 7.7355 | 0.0011 | 32.9219 | 32.9219 | 7.6581 | 7.6581 | 18379.5 | 18379.5 | Béton maquette archi | 0 STR BETON
Lisse basse | BEAM | GL24h | 22.4246 | 0.0003 | 22.501 | 22.501 | 1.2917 | 1.289 | 490.829 | 489.827 | MOB/FOB | A2 Salles | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Poutre-027 | BEAM | Béton | 11.3303 | 0.0009 | 37.5171 | 37.5171 | 7.1381 | 7.1381 | 17131.5 | 17131.5 | Béton maquette archi | 0 STR BETON
Poutre-028 | BEAM | Béton | 7.0115 | 0.001 | 28.4437 | 28.4437 | 6.3104 | 6.3104 | 15144.8 | 15144.8 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 4.02 | 0.0029 | 25.7042 | 25.7042 | 2.3316 | 2.2736 | 5595.84 | 5456.64 | Béton maquette archi | 0 STR BETON
2 x Membrure | BEAM | GL28h | 4.263 | 0.0006 | 7.77 | 7.77 | 0.8185 | 0.7669 | 335.585 | 314.419 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Me
M_Ext-012 | BEAM | Béton | 4.5435 | 0.0025 | 25.0607 | 25.0607 | 2.2263 | 2.2263 | 5343.19 | 5343.19 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 11.545 | 0.0007 | 30.8569 | 30.8569 | 4.8489 | 4.8489 | 11637.3 | 11637.3 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 8.06 | 0.0004 | 9.8448 | 9.8448 | 0.6964 | 0.6964 | 264.626 | 264.626 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Mur FOB | BEAM | MOB Paille | 43.858 | 0.0004 | 281.329 | 281.329 | 72.1517 | 42.896 | 1803.79 | 1072.4 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+3
2 x Poutre | BEAM | GL24h | 2.19 | 0.0003 | 2.0168 | 2.0168 | 0.0981 | 0.0981 | 37.2826 | 37.2826 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-013 | BEAM | Béton | 3.1978 | 0.0029 | 20.9861 | 20.9861 | 1.8547 | 1.8547 | 4451.29 | 4451.29 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 2.6427 | 0.0003 | 2.4784 | 2.4784 | 0.1321 | 0.1321 | 317.12 | 317.12 | Béton maquette archi | 0 STR BETON
2 x Poutre | BEAM | GL24h | 2.19 | 0.0003 | 2.0168 | 2.0168 | 0.0981 | 0.0981 | 37.2826 | 37.2826 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
MUR_EXT-029 | BEAM | Béton | 3.92 | 0.0029 | 25.464 | 25.464 | 2.2736 | 2.2736 | 5456.64 | 5456.64 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 2.1411 | 0.0006 | 4.3236 | 4.3236 | 0.4111 | 0.4111 | 168.545 | 168.545 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Me
Béton | BEAM | Béton | 11.0556 | 0.0032 | 70.289 | 70.289 | 7.164 | 6.2443 | 17193.7 | 14986.4 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 2.65 | 0.0004 | 2.7261 | 2.7261 | 0.1336 | 0.1318 | 50.7528 | 50.0958 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
M_Ext-016 | BEAM | Béton | 5.0002 | 0.0025 | 27.1542 | 27.1542 | 2.4501 | 2.4011 | 5880.26 | 5762.66 | Béton maquette archi | 0 STR BETON
2 x Membrure | BEAM | GL28h | 1.102 | 0.0006 | 2.1857 | 2.1857 | 0.2116 | 0.1861 | 86.7495 | 76.3177 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Me
M_Ext-013 | BEAM | Béton | 5.951 | 0.0025 | 32.1933 | 32.1933 | 2.916 | 2.867 | 6998.38 | 6880.78 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 5.25 | 0.0029 | 29.8634 | 29.8634 | 3.045 | 2.5547 | 7308 | 6131.33 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 2.15 | 0.0003 | 1.9856 | 1.9856 | 0.1006 | 0.1006 | 38.2356 | 38.2356 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Mur FOB | BEAM | MOB Paille | 32.7698 | 0.0004 | 319.3 | 319.3 | 64.0821 | 51.1084 | 1602.05 | 1277.71 | MOB/FOB | 2 B1 MOB 360 | Bât B Learning center | R+2
Membrure | BEAM | GL28h | 7.69 | 0.0006 | 13.8928 | 13.8928 | 1.378 | 1.378 | 565 | 565 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
2 x Poutre | BEAM | GL24h | 3.62 | 0.0004 | 4.0392 | 4.0392 | 0.2346 | 0.2346 | 89.1389 | 89.1389 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 2.15 | 0.0003 | 1.9856 | 1.9856 | 0.1006 | 0.1006 | 38.2356 | 38.2356 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-014 | BEAM | Béton | 3.607 | 0.0027 | 21.2882 | 21.2882 | 1.9478 | 1.8398 | 4674.72 | 4415.52 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 5.42 | 0.0029 | 34.764 | 34.764 | 3.1436 | 3.1436 | 7544.64 | 7544.64 | Béton maquette archi | 0 STR BETON
Mur FOB | BEAM | MOB Paille | 28.7777 | 0.0004 | 264.945 | 264.945 | 51.3625 | 42.1974 | 1284.06 | 1054.93 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+1
Poutre-027 | BEAM | Béton | 14.6 | 0.0008 | 41.84 | 41.84 | 7.008 | 7.008 | 16819.2 | 16819.2 | Béton maquette archi | 0 STR BETON
Lisse basse | BEAM | GL24h | 23.3448 | 0.0003 | 23.3825 | 23.3825 | 1.3447 | 1.3394 | 510.971 | 508.967 | MOB/FOB | A2 Salles | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Poutre-027 | BEAM | Béton | 5.4998 | 0.0011 | 19.9616 | 19.9616 | 4.2348 | 3.782 | 10163.6 | 9076.89 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 1.69 | 0.0004 | 1.9548 | 1.9548 | 0.1095 | 0.1095 | 41.6146 | 41.6146 | Charpente L.C. | 2 C1 Escalier | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Pr
2 x Poutre-027 | BEAM | Béton | 5.7 | 0.0006 | 13.14 | 13.14 | 1.71 | 1.71 | 4104 | 4104 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 18.9617 | 0.0006 | 35.1472 | 35.1472 | 3.6406 | 3.625 | 1492.67 | 1486.26 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Support de marche | BEAM | GL24h | 2.4343 | 0.0001 | 1.7386 | 1.7386 | 0.054 | 0.054 | 20.5138 | 20.5138 | Escalier | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Sous zone: Ruche
M_Ext-011 | BEAM | Béton | 4.2991 | 0.0025 | 24.6225 | 24.6225 | 2.1885 | 2.1885 | 5252.35 | 5252.35 | Béton maquette archi | 0 STR BETON
2 x Poutre | BEAM | GL24h | 3.87 | 0.0004 | 4.4335 | 4.4335 | 0.2857 | 0.2615 | 108.573 | 99.3529 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
2 x Poutre | BEAM | GL24h | 8.02 | 0.0006 | 12.4144 | 12.4144 | 0.8982 | 0.8982 | 341.331 | 341.331 | Charpente L.C. | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-011 | BEAM | Béton | 11.0556 | 0.0012 | 31.4357 | 31.4357 | 2.6533 | 2.6533 | 6368.04 | 6368.04 | Béton maquette archi | 0 STR BETON
2 x Poutre | BEAM | GL24h | 2.59 | 0.0005 | 3.96 | 3.96 | 0.2984 | 0.2984 | 113.38 | 113.38 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-011 | BEAM | Béton | 40.1679 | 0.0025 | 221.873 | 221.873 | 29.5234 | 29.4131 | 70856.2 | 70591.6 | Béton maquette archi | 0 STR BETON
Nervure | BEAM | GL24h | 2.6856 | 0.0005 | 3.3119 | 3.3119 | 0.2063 | 0.1805 | 78.3768 | 68.6024 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
Poutre-027 | BEAM | Béton | 5.4998 | 0.0011 | 21.3069 | 21.3069 | 4.2348 | 3.4418 | 10163.6 | 8260.32 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 0.4072 | 0.0003 | 0.4194 | 0.4194 | 0.016 | 0.0159 | 6.0649 | 6.0462 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
Poutre-027 | BEAM | Béton | 12.9379 | 0.0007 | 37.2061 | 37.2061 | 6.3396 | 6.3396 | 15215 | 15215 | Béton maquette archi | 0 STR BETON
MUR_EXT-029 | BEAM | Béton | 4.3201 | 0.0029 | 24.0979 | 24.0979 | 2.5056 | 2.0154 | 6013.55 | 4836.88 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 37.9244 | 0.0025 | 209.533 | 209.533 | 27.8744 | 27.7641 | 66898.6 | 66634 | Béton maquette archi | 0 STR BETON
6 x Support mur rideau | BEAM | GL24h | 0.82 | 0.0003 | 0.7672 | 0.7672 | 0.0321 | 0.0321 | 12.2147 | 12.2147 | Charpente L.C. | 2 A2 Salles | Bât A Autre Bâtiment | R+0
Nervure | BEAM | GL24h | 8.02 | 0.0005 | 10.3072 | 10.3072 | 0.6159 | 0.607 | 234.056 | 230.651 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
M_Ext-012 | BEAM | Béton | 5.1021 | 0.0014 | 16.8628 | 16.8628 | 1.4388 | 1.4244 | 3453.13 | 3418.47 | Béton maquette archi | 0 STR BETON
6 x Poutre | BEAM | GL24h | 4 | 0.0006 | 6.4192 | 6.4192 | 0.3584 | 0.3584 | 136.192 | 136.192 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre-027 | BEAM | Béton | 19.25 | 0.0008 | 50.85 | 50.85 | 7.7 | 7.7 | 18480 | 18480 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 10.8009 | 0.0007 | 28.9223 | 28.9223 | 4.5364 | 4.5364 | 10887.3 | 10887.3 | Béton maquette archi | 0 STR BETON
Lisse basse | BEAM | GL24h | 23.132 | 0.0003 | 23.2472 | 23.2472 | 1.3324 | 1.3324 | 506.313 | 506.313 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Complement | BEAM | GL24h | 5.79 | 0.0001 | 3.0428 | 3.0428 | 0.0926 | 0.0926 | 35.2032 | 35.2032 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Sous zone: Ruche
Lisse basse | BEAM | GL24h | 7.2683 | 0.0003 | 7.3835 | 7.3835 | 0.4187 | 0.4187 | 159.088 | 159.088 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Muraillère sur beton | BEAM | GL24h | 17.895 | 0.0005 | 24.3524 | 24.3524 | 1.4769 | 1.4769 | 561.214 | 561.214 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Mu; Sous zone: Terasse - restauration
Béton | BEAM | Béton | 10.5755 | 0.0033 | 75.2837 | 75.2837 | 7.0581 | 6.9246 | 16939.3 | 16619 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 19.5 | 0.0032 | 123.236 | 123.236 | 12.636 | 11.1032 | 30326.4 | 26647.7 | Béton maquette archi | 0 STR BETON
Complement | BEAM | GL24h | 0.605 | 0.0001 | 0.3466 | 0.3466 | 0.0097 | 0.0097 | 3.6784 | 3.6784 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Sous zone: Ruche
Lisse de chainage | BEAM | GL24h | 15.72 | 0.0004 | 13.248 | 13.248 | 0.3396 | 0.3396 | 129.03 | 129.03 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
2 x Poutre-027 | BEAM | Béton | 5.6477 | 0.0009 | 19.3326 | 19.3326 | 3.558 | 3.558 | 8539.31 | 8539.31 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 3.8161 | 0.0032 | 22.8414 | 22.8414 | 2.4423 | 1.85 | 5861.49 | 4440.02 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 3.9161 | 0.0032 | 20.9757 | 20.9757 | 2.5063 | 1.6417 | 6015.09 | 3940.15 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 8.18 | 0.0007 | 16.0864 | 16.0864 | 1.5575 | 1.5575 | 591.839 | 591.839 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Support mur rideau | BEAM | GL24h | 3.6923 | 0.0004 | 3.7383 | 3.7383 | 0.1861 | 0.1828 | 70.7152 | 69.4652 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
2 x Poutre-027 | BEAM | Béton | 24.9189 | 0.001 | 91.3081 | 91.3081 | 19.9351 | 19.9351 | 47844.3 | 47844.3 | Béton maquette archi | 0 STR BETON
Muraillère sur beton | BEAM | GL24h | 4.34 | 0.0005 | 6.0311 | 6.0311 | 0.3582 | 0.3582 | 136.109 | 136.109 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Mu; Sous zone: Terasse - restauration
Toit-09 | BEAM | Béton | 50.8 | 0.0207 | 1711.33 | 1711.33 | 315.07 | 249.37 | 756168 | 598488 | Béton maquette archi | 0 STR BETON
Poutre-028 | BEAM | Béton | 4.3427 | 0.0006 | 9.1655 | 9.1655 | 1.0423 | 1.0423 | 2501.41 | 2501.41 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.2985 | 0.0009 | 18.2152 | 18.2152 | 3.3381 | 3.3381 | 8011.33 | 8011.33 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 21.1 | 0.0007 | 51.34 | 51.34 | 7.385 | 7.385 | 17724 | 17724 | Béton maquette archi | 0 STR BETON
Support de marche | BEAM | GL24h | 2.1 | 0.0001 | 1.5758 | 1.5758 | 0.0494 | 0.0494 | 18.769 | 18.769 | Escalier | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Sous zone: Ruche
Poutre-027 | BEAM | Béton | 6.174 | 0.0008 | 15.4577 | 15.4577 | 1.9757 | 1.9757 | 4741.66 | 4741.66 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 0.4612 | 0.0003 | 0.4647 | 0.4647 | 0.0181 | 0.018 | 6.8694 | 6.8506 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
M_Ext-012 | BEAM | Béton | 5.0023 | 0.0027 | 29.6475 | 29.6475 | 2.6925 | 2.6387 | 6462.09 | 6332.91 | Béton maquette archi | 0 STR BETON
Complement | BEAM | GL24h | 0.29 | 0.0001 | 0.1828 | 0.1828 | 0.0046 | 0.0046 | 1.7632 | 1.7632 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Sous zone: Ruche
Lisse de chainage | BEAM | GL24h | 35.656 | 0.0004 | 29.9942 | 29.9942 | 0.7702 | 0.7702 | 292.664 | 292.664 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
Membrure | BEAM | GL28h | 9.6462 | 0.0008 | 22.518 | 22.518 | 2.5312 | 2.5312 | 1037.77 | 1037.77 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
2 x Poutre | BEAM | GL24h | 2.43 | 0.0003 | 2.232 | 2.232 | 0.1137 | 0.1137 | 43.2151 | 43.2151 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
3 x Poutre-027 | BEAM | Béton | 5.7 | 0.0007 | 16.94 | 16.94 | 2.793 | 2.793 | 6703.2 | 6703.2 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 4.512 | 0.0032 | 24.3755 | 24.3755 | 2.8877 | 2.064 | 6930.45 | 4953.61 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 3.4 | 0.0032 | 25.984 | 25.984 | 3.4816 | 3.4816 | 8355.84 | 8355.84 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 4.2834 | 0.0021 | 11.1029 | 11.1029 | 1.8152 | 0.5518 | 4356.44 | 1324.21 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 2.3143 | 0.0004 | 2.6291 | 2.6291 | 0.15 | 0.15 | 56.9879 | 56.9879 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 8.1 | 0.0006 | 14.9272 | 14.9272 | 1.4062 | 1.4062 | 534.341 | 534.341 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre acrotère | BEAM | GL24h | 8.66 | 0.0011 | 22.5554 | 22.5554 | 1.7138 | 1.7138 | 651.236 | 651.236 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-013 | BEAM | Béton | 17 | 0.0029 | 106.18 | 106.18 | 9.86 | 9.802 | 23664 | 23524.8 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 4.6991 | 0.0033 | 28.5605 | 28.5605 | 3.1014 | 2.4094 | 7443.37 | 5782.57 | Béton maquette archi | 0 STR BETON
Complement | BEAM | GL24h | 0.3456 | 0.0001 | 0.2117 | 0.2117 | 0.0055 | 0.0055 | 2.1014 | 2.1014 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Sous zone: Ruche
Poutre-027 | BEAM | Béton | 11.55 | 0.0009 | 38.5216 | 38.5216 | 7.2765 | 6.899 | 17463.6 | 16557.5 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 8.44 | 0.0007 | 18.214 | 18.214 | 2.0678 | 2.0678 | 4962.72 | 4962.72 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 4.9974 | 0.0005 | 9.9451 | 9.9451 | 1.1244 | 1.1244 | 2698.6 | 2698.6 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.885 | 0.0007 | 16.141 | 16.141 | 2.4717 | 2.4717 | 5932.08 | 5932.08 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 21.7825 | 0.0006 | 40.2111 | 40.2111 | 4.1822 | 4.151 | 1714.72 | 1701.9 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
M_Ext-011 | BEAM | Béton | 11.3543 | 0.0025 | 63.9186 | 63.9186 | 8.3454 | 8.3454 | 20029 | 20029 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 3.63 | 0.0004 | 3.5029 | 3.5029 | 0.183 | 0.1621 | 69.5218 | 61.6152 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
Complement | BEAM | GL24h | 0.6 | 0.0001 | 0.344 | 0.344 | 0.0096 | 0.0096 | 3.648 | 3.648 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Sous zone: Ruche
Complement | BEAM | GL24h | 5.48 | 0.0001 | 2.8816 | 2.8816 | 0.0877 | 0.0877 | 33.3184 | 33.3184 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Sous zone: Ruche
Béton | BEAM | Béton | 9.7045 | 0.0031 | 69.1136 | 69.1136 | 10.6313 | 10.4938 | 25515.1 | 25185.2 | Béton maquette archi | 0 STR BETON
3 x Poutre-027 | BEAM | Béton | 19.25 | 0.0008 | 58.87 | 58.87 | 10.78 | 10.78 | 25872 | 25872 | Béton maquette archi | 0 STR BETON
MUR_EXT-029 | BEAM | Béton | 2.3854 | 0.0018 | 10.3327 | 10.3327 | 0.8826 | 0.8599 | 2118.23 | 2063.78 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 14.0182 | 0.003 | 73.3759 | 73.3759 | 8.4109 | 6.3161 | 20186.2 | 15158.6 | Béton maquette archi | 0 STR BETON
M_Ext-016 | BEAM | Béton | 13.5294 | 0.0022 | 65.414 | 65.414 | 5.953 | 5.8694 | 14287.1 | 14086.4 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 10.8009 | 0.0008 | 33.5227 | 33.5227 | 6.0485 | 6.0485 | 14516.4 | 14516.4 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.3477 | 0.0008 | 14.704 | 14.704 | 2.1391 | 2.1391 | 5133.78 | 5133.78 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.4998 | 0.0011 | 21.3392 | 21.3392 | 4.2348 | 4.2348 | 10163.6 | 10163.6 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 6.1785 | 0.0021 | 29.3545 | 29.3545 | 2.6136 | 2.6035 | 6272.66 | 6248.32 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 39.8699 | 0.0028 | 239.573 | 239.573 | 33.3711 | 31.9559 | 80090.6 | 76694.1 | Béton maquette archi | 0 STR BETON
Poutre-028 | BEAM | Béton | 6.1849 | 0.0011 | 26.7198 | 26.7198 | 6.1231 | 6.1231 | 14695.4 | 14695.4 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.5181 | 0.0006 | 11.5161 | 11.5161 | 1.3243 | 1.3243 | 3178.41 | 3178.41 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.1616 | 0.0009 | 16.5648 | 16.5648 | 2.7873 | 2.7873 | 6689.41 | 6689.41 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 4.367 | 0.0025 | 24.5892 | 24.5892 | 3.2097 | 3.0319 | 7703.35 | 7276.55 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 3.4 | 0.0025 | 20.404 | 20.404 | 2.6656 | 2.6656 | 6397.44 | 6397.44 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 2.9283 | 0.0006 | 4.7259 | 4.7259 | 0.3163 | 0.3113 | 120.179 | 118.3 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-013 | BEAM | Béton | 4.512 | 0.0025 | 17.538 | 17.538 | 2.2109 | 1.4188 | 5306.12 | 3405.23 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 11.3543 | 0.0028 | 71.8435 | 71.8435 | 9.5035 | 9.5035 | 22808.5 | 22808.5 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 20.1511 | 0.0026 | 105.461 | 105.461 | 15.7934 | 13.2313 | 37904.2 | 31755.2 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.15 | 0.0008 | 16.5699 | 16.5699 | 2.884 | 2.884 | 6921.57 | 6921.57 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 10.0319 | 0.0032 | 69.0823 | 69.0823 | 6.4204 | 6.3564 | 15409.1 | 15255.5 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 10.5799 | 0.0007 | 28.3477 | 28.3477 | 4.4435 | 4.4435 | 10664.5 | 10664.5 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 9.2906 | 0.0004 | 9.3914 | 9.3914 | 0.4682 | 0.4682 | 177.933 | 177.933 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
M_Ext-013 | BEAM | Béton | 6.6498 | 0.0029 | 35.0757 | 35.0757 | 3.8569 | 2.9344 | 9256.59 | 7042.44 | Béton maquette archi | 0 STR BETON
M_Ext-017 | BEAM | Béton | 19.9511 | 0.0026 | 113.717 | 113.717 | 15.487 | 14.5933 | 37168.9 | 35024 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 11.3738 | 0.0006 | 28.0172 | 28.0172 | 4.0946 | 4.0946 | 9827.01 | 9827.01 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 15.7314 | 0.0013 | 47.1357 | 47.1357 | 4.0902 | 4.03 | 9816.4 | 9672.1 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 2.52 | 0.0025 | 13.6819 | 13.6819 | 1.2348 | 1.1368 | 2963.52 | 2728.32 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 8.02 | 0.0004 | 8.1208 | 8.1208 | 0.4042 | 0.4042 | 153.599 | 153.599 | Charpente L.C. | 2 A2 Salles | Bât A Autre Bâtiment | R+0
Poutre-027 | BEAM | Béton | 5.885 | 0.0009 | 20.092 | 20.092 | 3.7075 | 3.7075 | 8898.12 | 8898.12 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 10.4327 | 0.0007 | 27.965 | 27.965 | 4.3817 | 4.3817 | 10516.2 | 10516.2 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 10.2319 | 0.0028 | 50.675 | 50.675 | 5.7596 | 4.23 | 13823 | 10152.1 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 4.6991 | 0.0027 | 27.551 | 27.551 | 2.5305 | 2.3908 | 6073.25 | 5737.97 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 4.0708 | 0.0009 | 14.2866 | 14.2866 | 2.5646 | 2.5646 | 6155.09 | 6155.09 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 8.9623 | 0.0007 | 24.1419 | 24.1419 | 3.7642 | 3.7642 | 9033.98 | 9033.98 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 50.8 | 0.0022 | 252.994 | 252.994 | 33.3226 | 33.1258 | 79974.2 | 79502 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 4.367 | 0.0032 | 31.3588 | 31.3588 | 4.1923 | 3.96 | 10061.5 | 9504.06 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 10.0319 | 0.003 | 61.2598 | 61.2598 | 5.9575 | 5.5815 | 14297.9 | 13395.7 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 3.79 | 0.0006 | 7.3576 | 7.3576 | 0.7277 | 0.7277 | 298.349 | 298.349 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
M_Ext-012 | BEAM | Béton | 5.5705 | 0.0014 | 17.7401 | 17.7401 | 1.5941 | 1.5018 | 3825.89 | 3604.38 | Béton maquette archi | 0 STR BETON
M_Ext-011 | BEAM | Béton | 50.8 | 0.0025 | 279.829 | 279.829 | 37.338 | 37.1175 | 89611.2 | 89082 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 21.6646 | 0.0006 | 38.3665 | 38.3665 | 3.8823 | 3.8677 | 1591.74 | 1585.75 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Support mur rideau | BEAM | GL24h | 2.1069 | 0.0004 | 2.2077 | 2.2077 | 0.1062 | 0.1062 | 40.3513 | 40.3513 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
M_Ext-016 | BEAM | Béton | 5.0002 | 0.0023 | 25.8371 | 25.8371 | 2.294 | 2.292 | 5505.6 | 5500.8 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 4.9571 | 0.0031 | 27.1279 | 27.1279 | 3.1067 | 2.2232 | 7456.06 | 5335.67 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 4.5435 | 0.0032 | 32.176 | 32.176 | 2.9079 | 2.9079 | 6978.86 | 6978.86 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 2.12 | 0.0021 | 10.6796 | 10.6796 | 0.8984 | 0.8984 | 2156.17 | 2156.17 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 17.8653 | 0.0014 | 61.6886 | 61.6886 | 7.557 | 7.5147 | 18136.8 | 18035.3 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 21.6225 | 0.0025 | 115.579 | 115.579 | 10.595 | 10.595 | 25428 | 25428 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 2.894 | 0.0012 | 9.5112 | 9.5112 | 1.0567 | 1.0567 | 2536.02 | 2536.02 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 4.7694 | 0.0003 | 4.3924 | 4.3924 | 0.2385 | 0.2385 | 572.327 | 572.327 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 29.1264 | 0.0011 | 73.4868 | 73.4868 | 6.1577 | 6.1366 | 14778.5 | 14727.8 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 5.6688 | 0.0013 | 18.7347 | 18.7347 | 2.2297 | 2.1714 | 5351.36 | 5211.29 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 5.0023 | 0.0025 | 27.1651 | 27.1651 | 2.4511 | 2.4021 | 5882.68 | 5765.08 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 3.3161 | 0.0032 | 20.3625 | 20.3625 | 2.1223 | 1.69 | 5093.49 | 4056.02 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 9.7045 | 0.0032 | 68.8391 | 68.8392 | 9.3163 | 9.1243 | 22359.2 | 21898.4 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 2.52 | 0.0021 | 6.6784 | 6.6784 | 1.0679 | 0.3066 | 2563 | 735.857 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 4.2803 | 0.0025 | 23.3386 | 23.3386 | 2.0973 | 2.0483 | 5033.64 | 4916.04 | Béton maquette archi | 0 STR BETON
M_Ext-016 | BEAM | Béton | 13.5012 | 0.002 | 61.5752 | 61.5752 | 5.5355 | 5.5355 | 13285.1 | 13285.1 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 6.5365 | 0.0025 | 36.7235 | 36.7235 | 4.8044 | 4.6677 | 11530.5 | 11202.4 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 9.7045 | 0.0025 | 54.0415 | 54.0415 | 7.1328 | 6.9858 | 17118.8 | 16766 | Béton maquette archi | 0 STR BETON
MUR_EXT-029 | BEAM | Béton | 1.9346 | 0.0018 | 8.4846 | 8.4846 | 0.7158 | 0.6931 | 1717.95 | 1663.5 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 5.032 | 0.0032 | 35.4976 | 35.4976 | 3.2205 | 3.2205 | 7729.15 | 7729.15 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 8.02 | 0.0004 | 8.0587 | 8.0587 | 0.4042 | 0.3999 | 153.599 | 151.947 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
M_Ext-012 | BEAM | Béton | 4.2803 | 0.0032 | 29.9712 | 29.9712 | 2.7394 | 2.6754 | 6574.55 | 6420.95 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 2.9429 | 0.0025 | 17.7426 | 17.7426 | 2.3072 | 2.2876 | 5537.32 | 5490.3 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 4.31 | 0.0004 | 4.7844 | 4.7844 | 0.2793 | 0.2793 | 106.129 | 106.129 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-013 | BEAM | Béton | 9.7245 | 0.0029 | 50.6715 | 50.6715 | 5.6402 | 4.2853 | 13536.4 | 10284.8 | Béton maquette archi | 0 STR BETON
MUR_EXT-029 | BEAM | Béton | 7.3104 | 0.0029 | 24.8655 | 24.8655 | 4.2401 | 1.7463 | 10176.1 | 4191.21 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 6.0161 | 0.0025 | 28.6697 | 28.6697 | 2.9479 | 2.3931 | 7074.9 | 5743.43 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 3.82 | 0.0029 | 24.844 | 24.844 | 2.2156 | 2.2156 | 5317.44 | 5317.44 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 4.11 | 0.0006 | 7.9464 | 7.9464 | 0.7891 | 0.7891 | 323.539 | 323.539 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
2 x Poutre | BEAM | GL24h | 2.15 | 0.0004 | 2.4516 | 2.4516 | 0.1393 | 0.1393 | 52.9416 | 52.9416 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
M_Ext-012 | BEAM | Béton | 19.3998 | 0.003 | 123.399 | 123.399 | 11.4459 | 11.4459 | 27470.1 | 27470.1 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 4.3798 | 0.0029 | 24.848 | 24.8481 | 2.5403 | 2.108 | 6096.7 | 5059.23 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 10.0319 | 0.003 | 65.9341 | 65.9341 | 6.11 | 6.0491 | 14664 | 14517.8 | Béton maquette archi | 0 STR BETON

Properties of the parts of a building model (IFC4), part 2 of 4

# IfcBeam (1118)
Name | PredefinedType | Material | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | NetSurfaceArea (m2) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg) | Group | Repérage ensemble | Bâtiment | Niveaux
M_Ext-013 | BEAM | Béton | 5.951 | 0.0032 | 41.3319 | 41.3319 | 3.8086 | 3.7446 | 9140.74 | 8987.14 | Béton maquette archi | 0 STR BETON
M_Ext-012 | BEAM | Béton | 7.7 | 0.0022 | 32.2905 | 32.2905 | 3.388 | 2.7688 | 8131.2 | 6645.15 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 6.1458 | 0.0025 | 29.2816 | 29.2816 | 3.0729 | 2.4129 | 7374.98 | 5790.98 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 8.5815 | 0.0025 | 50.4576 | 50.4576 | 7.5088 | 7.4735 | 18021.1 | 17936.5 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 3.7629 | 0.0012 | 10.6625 | 10.6625 | 0.9031 | 0.8513 | 2167.44 | 2043.18 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 2.1846 | 0.0015 | 8.0278 | 8.0278 | 0.6554 | 0.6554 | 1572.95 | 1572.95 | Béton maquette archi | 0 STR BETON
M_Ext-021 | BEAM | Béton | 4.31 | 0.0027 | 25.3653 | 25.3654 | 2.3274 | 2.2194 | 5585.76 | 5326.56 | Béton maquette archi | 0 STR BETON
Lisse de chainage | BEAM | GL24h | 32.7768 | 0.0004 | 27.5014 | 27.5014 | 0.708 | 0.706 | 269.032 | 268.28 | MOB/FOB | A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
Mur FOB | BEAM | MOB Paille | 19.95 | 0.0004 | 138.445 | 138.445 | 25.544 | 22.9366 | 638.6 | 573.415 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+2
Béton | BEAM | Béton | 13.587 | 0.0027 | 69.9423 | 69.9423 | 7.337 | 6.0617 | 17608.7 | 14548 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 10.805 | 0.0022 | 52.4463 | 52.4463 | 4.7542 | 4.7102 | 11410.1 | 11304.5 | Béton maquette archi | 0 STR BETON
M_Ext-013 | BEAM | Béton | 6.4861 | 0.0029 | 34.0603 | 34.0603 | 3.7619 | 2.8394 | 9028.62 | 6814.47 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 1.6546 | 0.0015 | 6.0101 | 6.0101 | 0.4964 | 0.4664 | 1191.35 | 1119.35 | Béton maquette archi | 0 STR BETON
M_Ext-017 | BEAM | Béton | 19.93 | 0.0026 | 113.809 | 113.809 | 10.5131 | 10.4603 | 25231.4 | 25104.8 | Béton maquette archi | 0 STR BETON
M_Ext-014 | BEAM | Béton | 5.8102 | 0.003 | 37.9938 | 37.9938 | 3.4861 | 3.4261 | 8366.68 | 8222.68 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 17.9795 | 0.0008 | 43.8467 | 43.8467 | 5.7644 | 5.7644 | 13834.5 | 13834.5 | Béton maquette archi | 0 STR BETON
M_Ext-014 | BEAM | Béton | 3.82 | 0.0029 | 24.844 | 24.844 | 2.2156 | 2.2156 | 5317.44 | 5317.44 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 10.3755 | 0.0023 | 52.488 | 52.488 | 4.7727 | 4.7267 | 11454.5 | 11344.1 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 23.52 | 0.0025 | 105.919 | 105.919 | 11.76 | 9.5344 | 28224 | 22882.5 | Béton maquette archi | 0 STR BETON
MUR_EXT-029 | BEAM | Béton | 11.6061 | 0.0029 | 64.9429 | 64.9429 | 6.7315 | 5.7428 | 16155.7 | 13782.8 | Béton maquette archi | 0 STR BETON
Mur FOB | BEAM | MOB Paille | 23.132 | 0.0004 | 210.682 | 210.682 | 41.286 | 33.2687 | 1032.15 | 831.718 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+1
MUR_EXT-028 | BEAM | Béton | 8.46 | 0.0029 | 53.612 | 53.612 | 4.9068 | 4.9068 | 11776.3 | 11776.3 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 9.7045 | 0.0025 | 56.5523 | 56.5523 | 8.4915 | 8.3817 | 20379.5 | 20116 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 23.52 | 0.0029 | 126.809 | 126.809 | 13.6416 | 11.1041 | 32739.8 | 26649.9 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 4.68 | 0.0025 | 25.784 | 25.784 | 2.2932 | 2.2932 | 5503.68 | 5503.68 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 2.0025 | 0.0005 | 3.0034 | 3.0034 | 0.2002 | 0.2002 | 480.589 | 480.589 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 12.757 | 0.001 | 31.2 | 31.2 | 2.5694 | 2.5694 | 6166.65 | 6166.65 | Béton maquette archi | 0 STR BETON
M_Ext-015 | BEAM | Béton | 3.8195 | 0.0032 | 27.2527 | 27.2527 | 2.4445 | 2.4445 | 5866.77 | 5866.77 | Béton maquette archi | 0 STR BETON
M_Ext-020 | BEAM | Béton | 8.6573 | 0.0025 | 47.0835 | 47.0835 | 4.3286 | 4.2286 | 10388.7 | 10148.7 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 8.4015 | 0.0029 | 43.4042 | 43.4042 | 8.5275 | 5.5746 | 20466 | 13379 | Béton maquette archi | 0 STR BETON
2 x Poutre | BEAM | GL28h | 8.02 | 0.0006 | 12.4144 | 12.4144 | 0.8982 | 0.8982 | 368.278 | 368.278 | Charpente L.C. | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-014 | BEAM | Béton | 2.52 | 0.0021 | 6.6622 | 6.6622 | 1.0679 | 0.3048 | 2563 | 731.426 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 13.587 | 0.0027 | 79.1524 | 79.1524 | 7.337 | 7.219 | 17608.7 | 17325.7 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 6.4268 | 0.0029 | 40.7264 | 40.7264 | 3.7275 | 3.692 | 8946.11 | 8860.77 | Béton maquette archi | 0 STR BETON
M_Ext-017 | BEAM | Béton | 3.607 | 0.002 | 16.4913 | 16.4913 | 1.4789 | 1.3969 | 3549.33 | 3352.53 | Béton maquette archi | 0 STR BETON
M_Ext-014 | BEAM | Béton | 4.8883 | 0.0031 | 33.437 | 33.437 | 3.0635 | 3.0009 | 7352.48 | 7202.07 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 3.475 | 0.0006 | 5.5727 | 5.5727 | 0.3114 | 0.3098 | 118.317 | 117.715 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
M_Ext-014 | BEAM | Béton | 4.2803 | 0.0025 | 18.2585 | 18.2585 | 2.0973 | 1.5403 | 5033.64 | 3696.81 | Béton maquette archi | 0 STR BETON
M_Ext-017 | BEAM | Béton | 4.8688 | 0.0032 | 21.3244 | 21.3244 | 3.116 | 1.7508 | 7478.52 | 4201.86 | Béton maquette archi | 0 STR BETON
M_Ext-017 | BEAM | Béton | 9.5906 | 0.0027 | 56.7052 | 56.7052 | 5.1789 | 5.1789 | 12429.4 | 12429.4 | Béton maquette archi | 0 STR BETON
Poutre-028 | BEAM | Béton | 11.0502 | 0.0007 | 29.5706 | 29.5706 | 4.6411 | 4.6411 | 11138.6 | 11138.6 | Béton maquette archi | 0 STR BETON
Membrure | BEAM | GL28h | 6.9903 | 0.0006 | 12.54 | 12.54 | 1.2527 | 1.2381 | 513.593 | 507.613 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Mur FOB | BEAM | MOB Paille | 23.132 | 0.0004 | 193.748 | 193.748 | 38.0549 | 30.0376 | 951.373 | 750.941 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+3
Poutre | BEAM | GL24h | 4.37 | 0.0004 | 4.8492 | 4.8492 | 0.2832 | 0.2832 | 107.607 | 107.607 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Mur FOB | BEAM | MOB Paille | 16.108 | 0.0004 | 99.3414 | 99.3414 | 20.6247 | 13.6407 | 515.617 | 341.017 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+2
Support mur rideau | BEAM | GL24h | 0.3584 | 0.0003 | 0.3784 | 0.3784 | 0.014 | 0.014 | 5.3381 | 5.3193 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
Lisse basse | BEAM | GL24h | 28.7777 | 0.0003 | 28.8929 | 28.8929 | 1.6576 | 1.6576 | 629.887 | 629.887 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Poutre | BEAM | GL24h | 2.59 | 0.0007 | 5.6152 | 5.6152 | 0.5636 | 0.5636 | 214.162 | 214.162 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 2.15 | 0.0004 | 2.4516 | 2.4516 | 0.1393 | 0.1393 | 52.9416 | 52.9416 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Lisse basse | BEAM | GL24h | 19.95 | 0.0003 | 20.0652 | 20.0652 | 1.1491 | 1.1491 | 436.666 | 436.666 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Poutre | BEAM | GL24h | 8.38 | 0.0005 | 12.2976 | 12.2976 | 0.9654 | 0.9654 | 366.843 | 366.843 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Support de marche | BEAM | GL24h | 2.075 | 0.0001 | 1.4886 | 1.4886 | 0.046 | 0.046 | 17.4858 | 17.4858 | Escalier | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Sous zone: Ruche
Poutre-027 | BEAM | Béton | 15.2049 | 0.001 | 49.8557 | 49.8557 | 9.1229 | 9.1229 | 21895.1 | 21895.1 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 9.7906 | 0.001 | 32.5298 | 32.5298 | 5.8743 | 5.8743 | 14098.4 | 14098.4 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 19.598 | 0.0006 | 39.6759 | 39.6759 | 4.7035 | 4.7035 | 11288.4 | 11288.4 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 11.1574 | 0.0013 | 33.3327 | 33.3327 | 2.9009 | 2.8338 | 6962.22 | 6801.21 | Béton maquette archi | 0 STR BETON
Poutre | BEAM | GL24h | 3.89 | 0.0005 | 5.2804 | 5.2804 | 0.2832 | 0.2832 | 107.613 | 107.613 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Support mur rideau | BEAM | GL24h | 0.4342 | 0.0003 | 0.442 | 0.442 | 0.017 | 0.017 | 6.4671 | 6.4484 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
Membrure | BEAM | GL28h | 11.1879 | 0.0006 | 19.9277 | 19.9277 | 2.0049 | 1.9903 | 821.999 | 816.019 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
2 x Poutre | BEAM | GL24h | 2.43 | 0.0004 | 2.754 | 2.754 | 0.1575 | 0.1575 | 59.8363 | 59.8363 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Mur FOB | BEAM | MOB Paille | 16.108 | 0.0004 | 144.5 | 144.5 | 28.7496 | 22.3592 | 718.739 | 558.98 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+1
Membrure | BEAM | GL28h | 17.2694 | 0.0006 | 30.6311 | 30.6312 | 3.0947 | 3.0801 | 1268.82 | 1262.84 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Poutre | BEAM | GL24h | 2.43 | 0.0004 | 2.754 | 2.754 | 0.1575 | 0.1575 | 59.8363 | 59.8363 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Lisse de chainage | BEAM | GL24h | 20.336 | 0.0004 | 17.1254 | 17.1254 | 0.4393 | 0.4393 | 166.918 | 166.918 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
Poutre | BEAM | GL24h | 2.43 | 0.0003 | 2.232 | 2.232 | 0.1137 | 0.1137 | 43.2151 | 43.2151 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 1.4511 | 0.0004 | 2.3359 | 2.3359 | 0.1788 | 0.1788 | 67.9335 | 67.9335 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
4 x Poutre | BEAM | GL24h | 8.06 | 0.0005 | 11.8368 | 11.8368 | 0.9285 | 0.9285 | 352.835 | 352.835 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 8.1 | 0.0005 | 13.2512 | 13.2512 | 1.1794 | 1.1794 | 448.157 | 448.157 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 3.67 | 0.0006 | 5.2948 | 5.2948 | 0.2877 | 0.2877 | 109.337 | 109.337 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 4.3512 | 0.0006 | 6.9671 | 6.9671 | 0.3899 | 0.3899 | 148.15 | 148.15 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Membrure | BEAM | GL28h | 3.6488 | 0.0006 | 6.8658 | 6.8658 | 0.7006 | 0.6744 | 287.234 | 276.5 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Me
4 x Poutre | BEAM | GL24h | 3.62 | 0.0004 | 4.0392 | 4.0392 | 0.2346 | 0.2346 | 89.1389 | 89.1389 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 3.89 | 0.0005 | 5.6332 | 5.6332 | 0.3641 | 0.3641 | 138.359 | 138.359 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 2.59 | 0.0004 | 3.2808 | 3.2808 | 0.2238 | 0.2238 | 85.0349 | 85.0349 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 3.67 | 0.0006 | 5.6332 | 5.6332 | 0.3699 | 0.3699 | 140.576 | 140.576 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 3.93 | 0.0004 | 4.8888 | 4.8888 | 0.3396 | 0.3396 | 129.03 | 129.03 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 2.4544 | 0.0004 | 2.7803 | 2.7803 | 0.159 | 0.159 | 60.4364 | 60.4364 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Complement | BEAM | GL24h | 5.48 | 0.0001 | 2.8816 | 2.8816 | 0.0877 | 0.0877 | 33.3184 | 33.3184 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Sous zone: Ruche
Complement | BEAM | GL24h | 3.1297 | 0.0001 | 1.6594 | 1.6594 | 0.0501 | 0.0501 | 19.0284 | 19.0284 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Sous zone: Ruche
Poutre | BEAM | GL24h | 8.1 | 0.0009 | 18.18 | 18.18 | 1.458 | 1.458 | 554.04 | 554.04 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 4.865 | 0.0004 | 5.3838 | 5.3838 | 0.3153 | 0.3153 | 119.796 | 119.796 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 3.89 | 0.0004 | 4.8408 | 4.8408 | 0.3361 | 0.3361 | 127.716 | 127.716 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Nervure | BEAM | GL24h | 7.1631 | 0.0005 | 9.0431 | 9.0431 | 0.5501 | 0.5244 | 209.048 | 199.274 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
Support mur rideau | BEAM | GL24h | 1.261 | 0.0004 | 1.3356 | 1.3356 | 0.0636 | 0.062 | 24.1511 | 23.5589 | Charpente L.C. | 2 A2 Salles | Bât A Autre Bâtiment | R+0
2 x Poutre | BEAM | GL24h | 2.59 | 0.0005 | 3.96 | 3.96 | 0.2984 | 0.2984 | 113.38 | 113.38 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Nervure | BEAM | GL24h | 4.6515 | 0.0005 | 5.8283 | 5.8283 | 0.3572 | 0.3315 | 135.751 | 125.976 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
Nervure | BEAM | GL24h | 6.6175 | 0.0005 | 8.3447 | 8.3447 | 0.5082 | 0.4825 | 193.125 | 183.35 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
Nervure | BEAM | GL24h | 3.2312 | 0.0005 | 4.0103 | 4.0103 | 0.2482 | 0.2224 | 94.3001 | 84.5258 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
Nervure | BEAM | GL24h | 5.1972 | 0.0005 | 6.5267 | 6.5267 | 0.3991 | 0.3734 | 151.674 | 141.9 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+1
Mur FOB | BEAM | MOB Paille | 20.326 | 0.0004 | 182.41 | 182.41 | 33.4387 | 31.2678 | 835.968 | 781.696 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+3
2 x Poutre | BEAM | GL24h | 3.88 | 0.0005 | 5.011 | 5.011 | 0.3352 | 0.3108 | 127.388 | 118.121 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Membrure | BEAM | GL28h | 12.9027 | 0.0006 | 23.9986 | 23.9986 | 2.4773 | 2.4617 | 1015.7 | 1009.29 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Complement | BEAM | GL24h | 8.1 | 0.0001 | 4.244 | 4.244 | 0.1296 | 0.1296 | 49.248 | 49.248 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Sous zone: Ruche
Poutre | BEAM | GL24h | 5.345 | 0.0006 | 8.5702 | 8.5702 | 0.62 | 0.62 | 235.608 | 235.608 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 2.57 | 0.0004 | 3.0224 | 3.0224 | 0.185 | 0.185 | 70.3152 | 70.3152 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
2 x Poutre | BEAM | GL24h | 2.19 | 0.0003 | 2.0168 | 2.0168 | 0.0981 | 0.0981 | 37.2826 | 37.2826 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Complement | BEAM | GL24h | 0.18 | 0.0001 | 0.1256 | 0.1256 | 0.0029 | 0.0029 | 1.0944 | 1.0944 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Sous zone: Ruche
Mur FOB | BEAM | MOB Paille | 22.4246 | 0.0004 | 218.953 | 218.953 | 43.8517 | 35.0771 | 1096.29 | 876.928 | MOB/FOB | 2 B1 MOB 360 | Bât B Learning center | R+2
Poutre | BEAM | GL24h | 3.5021 | 0.0006 | 5.606 | 5.606 | 0.3138 | 0.3117 | 119.238 | 118.441 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Lièrne BLC | BEAM | GL24h | 24.6654 | 0.0002 | 16.6745 | 16.6745 | 0.6906 | 0.6514 | 262.44 | 247.528 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Li
Poutre | BEAM | GL24h | 1.7497 | 0.0006 | 2.8366 | 2.8366 | 0.1568 | 0.152 | 59.5741 | 57.7592 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Mur FOB | BEAM | MOB Paille | 16.108 | 0.0004 | 136.233 | 136.233 | 26.4996 | 20.7494 | 662.49 | 518.736 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+3
Poutre | BEAM | GL24h | 3.5052 | 0.0006 | 5.6198 | 5.6198 | 0.3141 | 0.3125 | 119.344 | 118.742 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 1.593 | 0.0006 | 2.6279 | 2.6279 | 0.1427 | 0.1406 | 54.2398 | 53.4421 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Complement | BEAM | GL24h | 2.8456 | 0.0001 | 1.5117 | 1.5117 | 0.0455 | 0.0455 | 17.3014 | 17.3014 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Sous zone: Ruche
Poutre | BEAM | GL24h | 3.5119 | 0.0006 | 5.6214 | 5.6214 | 0.3147 | 0.3126 | 119.573 | 118.776 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Mur FOB | BEAM | MOB Paille | 19.95 | 0.0004 | 176.68 | 176.68 | 32.8201 | 30.2128 | 820.504 | 755.32 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+3
Mur FOB | BEAM | MOB Paille | 35.658 | 0.0004 | 295.617 | 295.617 | 58.6617 | 45.439 | 1466.54 | 1135.97 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+3
Mur FOB | BEAM | MOB Paille | 23.132 | 0.0004 | 149.53 | 149.53 | 29.6182 | 21.6009 | 740.455 | 540.023 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+2
Mur FOB | BEAM | MOB Paille | 23.52 | 0.0004 | 140.127 | 140.127 | 29.5675 | 19.0915 | 739.187 | 477.287 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+1
Mur FOB | BEAM | MOB Paille | 19.95 | 0.0004 | 193.186 | 193.186 | 35.6068 | 32.9994 | 890.169 | 824.985 | MOB/FOB | 2 B1 MOB 360 | Bât A Autre Bâtiment | R+1
Mur FOB | BEAM | MOB Paille | 23.4506 | 0.0004 | 242.57 | 242.57 | 45.8582 | 40.8279 | 1146.45 | 1020.7 | MOB/FOB | 2 B1 MOB 360 | Bât B Learning center | R+2
Poutre-027 | BEAM | Béton | 6.1092 | 0.0011 | 23.5467 | 23.5467 | 4.7083 | 4.7083 | 11300 | 11300 | Béton maquette archi | 0 STR BETON
Lièrne BLC | BEAM | GL24h | 3.55 | 0.0002 | 2.47 | 2.47 | 0.0994 | 0.0994 | 37.772 | 37.772 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Li
Béton | BEAM | Béton | 16.1711 | 0.001 | 40.6212 | 40.6212 | 3.3865 | 3.333 | 8127.48 | 7999.09 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 5.25 | 0.0011 | 20.44 | 20.44 | 4.0425 | 4.0425 | 9702 | 9702 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 19.3 | 0.0023 | 87.98 | 87.98 | 8.878 | 7.69 | 21307.2 | 18456 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 23.47 | 0.0008 | 61.822 | 61.822 | 9.388 | 9.388 | 22531.2 | 22531.2 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 2.5052 | 0.0007 | 7.9946 | 7.9946 | 1.2276 | 1.2276 | 2946.13 | 2946.13 | Béton maquette archi | 0 STR BETON
Béton | BEAM | Béton | 43.0911 | 0.0235 | 1311.92 | 1311.92 | 232.802 | 137.749 | 558724 | 330597 | Béton maquette archi | 0 STR BETON
Poutre-027 | BEAM | Béton | 24.9189 | 0.001 | 80.9406 | 80.9406 | 14.9514 | 14.9514 | 35883.3 | 35883.3 | Béton maquette archi | 0 STR BETON
Support mur rideau | BEAM | GL24h | 1.3742 | 0.0004 | 1.4479 | 1.4479 | 0.0693 | 0.0676 | 26.3196 | 25.7024 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
Poutre | BEAM | GL24h | 8.18 | 0.0005 | 13.3792 | 13.3792 | 1.191 | 1.191 | 452.583 | 452.583 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Poutre | BEAM | GL24h | 8.06 | 0.0005 | 11.1536 | 11.1536 | 0.7738 | 0.7738 | 294.029 | 294.029 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 2.19 | 0.0005 | 3.384 | 3.384 | 0.2523 | 0.2523 | 95.8694 | 95.8694 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 3.0039 | 0.0006 | 4.8377 | 4.8377 | 0.2691 | 0.2676 | 102.276 | 101.674 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Lièrne BLC | BEAM | GL24h | 9.0044 | 0.0002 | 6.174 | 6.174 | 0.2521 | 0.2519 | 95.8063 | 95.7282 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Li
Lièrne BLC | BEAM | GL24h | 9.1425 | 0.0002 | 6.2692 | 6.2692 | 0.256 | 0.2558 | 97.2765 | 97.2177 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Li
Muraillère sur beton | BEAM | GL24h | 8.02 | 0.0005 | 10.3744 | 10.3744 | 0.6159 | 0.6124 | 234.056 | 232.694 | Plancher CLT nervure | 2 A3 Plancher CLT nervuré | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Mu
Poutre acrotère | BEAM | GL24h | 8.38 | 0.0011 | 21.8389 | 21.8389 | 1.6584 | 1.6584 | 630.179 | 630.179 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Pr
Poutre | BEAM | GL24h | 1.69 | 0.0005 | 2.4036 | 2.4036 | 0.146 | 0.146 | 55.4861 | 55.4861 | Charpente L.C. | 2 C1 Escalier | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Pr
Support mur rideau | BEAM | GL24h | 2.9302 | 0.0004 | 3.0036 | 3.0036 | 0.1477 | 0.146 | 56.1194 | 55.4944 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
Support mur rideau | BEAM | GL24h | 0.5152 | 0.0003 | 0.5101 | 0.5101 | 0.0202 | 0.0201 | 7.6738 | 7.655 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
Support mur rideau | BEAM | GL24h | 0.4882 | 0.0003 | 0.4874 | 0.4874 | 0.0191 | 0.0191 | 7.2716 | 7.2528 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
Support mur rideau | BEAM | GL24h | 0.3801 | 0.0003 | 0.3967 | 0.3967 | 0.0149 | 0.0149 | 5.6627 | 5.6439 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
Membrure | BEAM | GL28h | 9.6462 | 0.0006 | 18.1329 | 18.1329 | 1.8521 | 1.8521 | 759.345 | 759.345 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis
Lisse basse | BEAM | GL24h | 32.664 | 0.0003 | 32.7405 | 32.7405 | 1.8814 | 1.8788 | 714.95 | 713.948 | MOB/FOB | A2 Salles | Bât B Learning center | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Lisse basse | BEAM | GL24h | 19.3605 | 0.0003 | 19.4757 | 19.4757 | 1.1152 | 1.1152 | 423.763 | 423.763 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Lisse ba.
Poutre | BEAM | GL24h | 3.3 | 0.0004 | 3.6936 | 3.6936 | 0.2138 | 0.2138 | 81.2592 | 81.2592 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | R+1 | Cadwork3dProperties - Nom export 2d: Pr; Sous zone: Ruche
Lisse de chainage | BEAM | GL24h | 23.4027 | 0.0004 | 19.5529 | 19.5529 | 0.5055 | 0.5015 | 192.09 | 190.587 | MOB/FOB | A2 Salles | Bât B Learning center | R+2 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
Support mur rideau | BEAM | GL24h | 1.6597 | 0.0004 | 1.7333 | 1.7333 | 0.0836 | 0.082 | 31.7861 | 31.1689 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | R+0
Support mur rideau | BEAM | GL24h | 3.5281 | 0.0004 | 3.5758 | 3.5758 | 0.1778 | 0.1747 | 67.5698 | 66.3682 | Charpente L.C. | 2 A2 Salles | Bât A Autre Bâtiment | R+0
Lisse de chainage | BEAM | GL24h | 19.936 | 0.0004 | 16.7894 | 16.7894 | 0.4306 | 0.4306 | 163.635 | 163.635 | MOB/FOB | A2 Salles | Bât A Autre Bâtiment | R+3 | Cadwork3dProperties - Nom export 2d: Lisse Ch.
Support mur rideau | BEAM | GL24h | 1.4864 | 0.0004 | 1.4982 | 1.4982 | 0.0749 | 0.069 | 28.467 | 26.2057 | Charpente L.C. | 2 A2 Salles | Bât A Autre Bâtiment | R+0
Poutre | BEAM | GL24h | 8.34 | 0.0007 | 17.1152 | 17.1152 | 1.8148 | 1.8148 | 689.618 | 689.618 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | R+0 | Cadwork3dProperties - Nom export 2d: Pr
Membrure | BEAM | GL28h | 14.3829 | 0.0006 | 26.7221 | 26.7221 | 2.7615 | 2.7459 | 1132.22 | 1125.81 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | R+0 | Cadwork3dProperties - Nom export 2d: Me; Sous zone: Poutre treillis

# IfcBeam: Column (5)
In: Storey 1
PredefinedType: USERDEFINED; Material: GL24h
BaseQuantities - Length: 2.43 m; CrossSectionArea: 0.0004 m2; OuterSurfaceArea: 2.4192 m2; NetSurfaceArea: 2.4192 m2; GrossVolume: 0.105 m3; NetVolume: 0.105 m3; GrossWeight: 39.8909 kg; NetWeight: 39.8909 kg
Cadwork3dProperties - Group: Charpente L.C.; Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: A6 Bulles; Nom export 2d: Pt; Niveaux: R+3

# IfcBuildingElementProxy (233)
In: Storey 1
Name | NetSurfaceArea (m2) | NetVolume (m3) | Group
6 x Coupe | 0 | 0 | Trame
173 x Files | 0 | 0 | Trame
19 x  | 0 | 0 | Trame | Material: Sapin
5 x Gradin CLT | 4.1264 | 0.0728 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: C1 Escalier; Sous zone: Ruche; Niveaux: R+1
8 x Caisson toiture | 34.945 | 3.7714 | MOB/FOB | Material: MOB Tradi; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Sous zone: Ruche; Niveaux: R+4
8 x Caisson toiture | 10.5877 | 0.953 | MOB/FOB | Material: MOB Tradi; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Sous zone: Ruche; Niveaux: R+4
6 x Gradin CLT | 7.1236 | 0.1323 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: C1 Escalier; Sous zone: Ruche; Niveaux: R+1
Escalier CLT | 26.8631 | 1.9611 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: C1 Escalier; Sous zone: Ruche; Niveaux: R+1
Escalier CLT | 26.5573 | 2.1113 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât B Learning center; Repérage ensemble: 2 C1 Escalier; Niveaux: R+1
Escalier CLT | 26.3142 | 1.945 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: 2 C1 Escalier; Sous zone: Ruche; Niveaux: R+0
Gradin CLT | 3.4736 | 0.0598 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: C1 Escalier; Sous zone: Ruche; Niveaux: R+1
Escalier CLT | 13.915 | 1.0028 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: C1 Escalier; Sous zone: Ruche; Niveaux: R+1
Escalier CLT | 17.9579 | 1.3225 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: 2 C1 Escalier; Sous zone: Ruche; Niveaux: R+2
Escalier CLT | 17.0638 | 1.3058 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: 2 C1 Escalier; Sous zone: Ruche; Niveaux: R+2
Escalier CLT | 29.4782 | 2.1594 | Escalier | Material: CLT; Cadwork3dProperties - Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: 2 C1 Escalier; Sous zone: Ruche; Niveaux: R+0

# IfcColumn (694)
In: Storey 1
Name | PredefinedType | Material | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | NetSurfaceArea (m2) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg) | Group | Repérage ensemble | Bâtiment | Nom export 2d | Niveaux
POTEAU-002 | COLUMN | Béton | 2.94 | 0.0004 | 4.0227 | 4.0227 | 0.2941 | 0.2941 | 705.801 | 705.801 | Béton maquette archi | 0 STR BETON
3 x Poteau | COLUMN | GL24h | 5.19 | 0.0003 | 6.848 | 6.848 | 0.5315 | 0.5315 | 201.953 | 201.953 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Pt | R+0
28 x POTEAU-002 | COLUMN | Béton | 2.45 | 0.0007 | 5.005 | 5.005 | 0.4288 | 0.4288 | 1029 | 1029 | Béton maquette archi | 0 STR BETON
61 x POTEAU-002 | COLUMN | Béton | 2.94 | 0.0007 | 5.936 | 5.936 | 0.5145 | 0.5145 | 1234.8 | 1234.8 | Béton maquette archi | 0 STR BETON
Montant | COLUMN | GL24h | 4.59 | 0.0003 | 6.08 | 6.08 | 0.47 | 0.47 | 178.606 | 178.606 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Mt | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
14 x Poteau en V |  | GL24h | 5.2633 | 0.0006 | 9.5889 | 9.5889 | 1.0105 | 0.9598 | 384.007 | 364.726 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
Montant | COLUMN | GL24h | 3.37 | 0.0005 | 4.8158 | 4.8158 | 0.4309 | 0.3637 | 163.735 | 138.2 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
12 x Poteau en V |  | GL24h | 3.2954 | 0.0006 | 5.9638 | 5.9638 | 0.6327 | 0.5815 | 240.431 | 220.962 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
25 x Poteau | COLUMN | GL24h | 3.3 | 0.0003 | 3.8496 | 3.8496 | 0.2534 | 0.2534 | 96.3072 | 96.3072 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+2
2 x Diagonale |  | GL24h | 4.7878 | 0.0002 | 4.5242 | 4.5242 | 0.2758 | 0.2617 | 104.796 | 99.4318 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+3
M_Ext-013 | COLUMN | Béton | 3.2 | 0.0025 | 17.5862 | 17.5862 | 1.6128 | 1.4848 | 3870.72 | 3563.52 | Béton maquette archi | 0 STR BETON
3 x POTEAU-001 | COLUMN | Béton | 4.7 | 0.0004 | 6.3131 | 6.3131 | 0.4706 | 0.4706 | 1129.37 | 1129.37 | Béton maquette archi | 0 STR BETON
6 x Diagonale secondaire |  | GL24h | 3.5799 | 0.0003 | 3.9837 | 3.9837 | 0.2749 | 0.2621 | 104.475 | 99.5882 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
8 x POTEAU-002 | COLUMN | Béton | 2.19 | 0.0007 | 4.511 | 4.511 | 0.3832 | 0.3832 | 919.8 | 919.8 | Béton maquette archi | 0 STR BETON
10 x Poteau | COLUMN | GL24h | 3.2951 | 0.0003 | 3.8441 | 3.8441 | 0.2531 | 0.2531 | 96.1638 | 96.1638 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
25 x Poteau | COLUMN | GL24h | 3.3 | 0.0003 | 3.5664 | 3.5664 | 0.2218 | 0.2218 | 84.2688 | 84.2688 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+2
14 x POTEAU-002 | COLUMN | Béton | 2.45 | 0.0007 | 5.005 | 5.005 | 0.4287 | 0.4287 | 1029 | 1029 | Béton maquette archi | 0 STR BETON
4 x POTEAU-002 | COLUMN | Béton | 2.2945 | 0.0007 | 4.6962 | 4.6963 | 0.4015 | 0.4003 | 963.683 | 960.743 | Béton maquette archi | 0 STR BETON
4 x Diagonale |  | GL24h | 4.7062 | 0.0002 | 4.6332 | 4.6332 | 0.2711 | 0.2711 | 103.01 | 103.01 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+1
26 x Poteau | COLUMN | GL24h | 3.57 | 0.0003 | 3.8472 | 3.8472 | 0.2399 | 0.2399 | 91.1635 | 91.1635 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+3
16 x Poteau | COLUMN | GL24h | 3.23 | 0.0003 | 3.7712 | 3.7712 | 0.2481 | 0.2481 | 94.2643 | 94.2643 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+3
4 x POTEAU-001 | COLUMN | Béton | 4.7 | 0.0004 | 6.1575 | 6.1575 | 0.752 | 0.5906 | 1804.8 | 1417.49 | Béton maquette archi | 0 STR BETON
Diagonale |  | GL24h | 5.0633 | 0.0002 | 4.976 | 4.976 | 0.2916 | 0.2916 | 110.825 | 110.825 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+3
18 x POTEAU-002 | COLUMN | Béton | 2.19 | 0.0007 | 4.511 | 4.511 | 0.3833 | 0.3833 | 919.8 | 919.8 | Béton maquette archi | 0 STR BETON
23 x Poteau | COLUMN | GL24h | 3.21 | 0.0003 | 3.7488 | 3.7488 | 0.2465 | 0.2465 | 93.6806 | 93.6806 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+1
2 x Diagonale |  | GL24h | 4.2344 | 0.0003 | 4.5978 | 4.5978 | 0.332 | 0.3041 | 126.152 | 115.56 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+2 | Cadwork3dProperties - Sous zone: Ruche
2 x Poteau | COLUMN | GL24h | 3.68 | 0.0003 | 3.9616 | 3.9616 | 0.2473 | 0.2473 | 93.9725 | 93.9725 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
3 x POTEAU-001 | COLUMN | Béton | 5.0685 | 0.0005 | 8.9764 | 8.9764 | 0.9123 | 0.9123 | 2189.59 | 2189.59 | Béton maquette archi | 0 STR BETON
4 x Poteau en V |  | GL24h | 5.0205 | 0.0006 | 9.1423 | 9.1423 | 0.9639 | 0.9132 | 366.297 | 347.017 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
2 x Diagonale |  | GL24h | 5.4489 | 0.0002 | 5.3461 | 5.3461 | 0.3139 | 0.3139 | 119.264 | 119.264 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag | R+2
7 x POTEAU-001 | COLUMN | Béton | 2.5 | 0.0004 | 3.16 | 3.16 | 0.2 | 0.2 | 480 | 480 | Béton maquette archi | 0 STR BETON
2 x Diagonale |  | GL24h | 4.2768 | 0.0003 | 4.6416 | 4.6416 | 0.3353 | 0.307 | 127.415 | 116.661 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+3 | Cadwork3dProperties - Sous zone: Ruche
2 x Montant | COLUMN | GL24h | 2.59 | 0.0003 | 3.0544 | 3.0544 | 0.1989 | 0.1989 | 75.5866 | 75.5866 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
2 x Montant | COLUMN | GL24h | 2.81 | 0.0003 | 3.3008 | 3.3008 | 0.2158 | 0.2158 | 82.007 | 82.007 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
8 x Poteau | COLUMN | GL24h | 3.3 | 0.0003 | 3.8528 | 3.8528 | 0.2587 | 0.2587 | 98.3136 | 98.3136 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+2 | Cadwork3dProperties - Sous zone: Ruche
Poteau | COLUMN | GL24h | 3.3 | 0.0003 | 3.8528 | 3.8528 | 0.2587 | 0.2587 | 98.3136 | 98.3136 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+1 | Cadwork3dProperties - Sous zone: Ruche
4 x Diagonale |  | GL24h | 4.2739 | 0.0003 | 4.6385 | 4.6385 | 0.3351 | 0.3068 | 127.328 | 116.584 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+3 | Cadwork3dProperties - Sous zone: Ruche
Poteau en V |  | GL24h | 6.5706 | 0.0006 | 11.7131 | 11.7131 | 1.2615 | 1.1746 | 479.388 | 446.341 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
M_Ext-014 | COLUMN | Béton | 3.2 | 0.0022 | 15.8251 | 15.8251 | 1.408 | 1.344 | 3379.2 | 3225.6 | Béton maquette archi | 0 STR BETON
M_Ext-011 | COLUMN | Béton | 3.2 | 0.0021 | 15.696 | 15.696 | 1.3568 | 1.3568 | 3256.32 | 3256.32 | Béton maquette archi | 0 STR BETON
23 x Poteau | COLUMN | GL24h | 3.21 | 0.0003 | 3.4728 | 3.4728 | 0.2157 | 0.2157 | 81.9706 | 81.9706 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+1
2 x Diagonale |  | GL24h | 5.4269 | 0.0002 | 5.325 | 5.325 | 0.3126 | 0.3126 | 118.784 | 118.784 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+3
8 x POTEAU-003 | COLUMN | Béton | 2.94 | 0.0007 | 5.936 | 5.936 | 0.5145 | 0.5145 | 1234.8 | 1234.8 | Béton maquette archi | 0 STR BETON
4 x Poteau | COLUMN | GL24h | 4.93 | 0.0003 | 5.6784 | 5.6784 | 0.3865 | 0.3865 | 146.875 | 146.875 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+3 | Cadwork3dProperties - Sous zone: Ruche
Poteau en V |  | GL24h | 8.8464 | 0.0006 | 16.0767 | 16.0767 | 1.6985 | 1.6372 | 645.437 | 622.122 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Pt(v) | R+0
M_Ext-013 | COLUMN | Béton | 2.45 | 0.0012 | 6.9467 | 6.9467 | 0.6096 | 0.5144 | 1462.97 | 1234.52 | Béton maquette archi | 0 STR BETON
POTEAU-002 | COLUMN | Béton | 2.19 | 0.0007 | 5.378 | 5.378 | 0.6132 | 0.6132 | 1471.68 | 1471.68 | Béton maquette archi | 0 STR BETON
2 x Poteau | COLUMN | GL24h | 3.31 | 0.0003 | 3.864 | 3.864 | 0.2595 | 0.2595 | 98.6115 | 98.6115 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+1 | Cadwork3dProperties - Sous zone: Ruche
10 x POTEAU-002 | COLUMN | Béton | 2.94 | 0.0007 | 6.3 | 6.3 | 0.6174 | 0.6174 | 1481.76 | 1481.76 | Béton maquette archi | 0 STR BETON
2 x POTEAU-002 | COLUMN | Béton | 2.94 | 0.0005 | 5.004 | 5.004 | 0.441 | 0.441 | 1058.4 | 1058.4 | Béton maquette archi | 0 STR BETON
2 x Diagonale |  | GL24h | 4.3571 | 0.0003 | 4.7245 | 4.7245 | 0.3416 | 0.3125 | 129.807 | 118.746 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+1 | Cadwork3dProperties - Sous zone: Ruche
3 x Poteau | COLUMN | GL24h | 2.84 | 0.0002 | 2.1096 | 2.1096 | 0.092 | 0.092 | 34.9661 | 34.9661 | Charpente L.C. | A6 Bulles | Bât A Autre Bâtiment | Pt | R+2 | Cadwork3dProperties - Sous zone: Ruche
POTEAU-002 | COLUMN | Béton | 2.5 | 0.0007 | 5.42 | 5.42 | 0.525 | 0.525 | 1260 | 1260 | Béton maquette archi | 0 STR BETON
4 x Diagonale |  | GL24h | 4.2739 | 0.0003 | 4.6385 | 4.6385 | 0.3351 | 0.3068 | 127.328 | 116.584 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+2 | Cadwork3dProperties - Sous zone: Ruche
3 x Diagonale |  | GL24h | 5.03 | 0.0002 | 4.944 | 4.944 | 0.2897 | 0.2897 | 110.097 | 110.097 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag | R+2
8 x POTEAU-002 | COLUMN | Béton | 2.45 | 0.0007 | 5.32 | 5.32 | 0.5145 | 0.5145 | 1234.8 | 1234.8 | Béton maquette archi | 0 STR BETON
Poteau |  | GL24h | 3.4857 | 0.0003 | 4.0539 | 4.0539 | 0.2677 | 0.2674 | 101.728 | 101.631 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt | R+2
4 x POTEAU-003 | COLUMN | Béton | 2.45 | 0.0007 | 5.005 | 5.005 | 0.4287 | 0.4287 | 1029 | 1029 | Béton maquette archi | 0 STR BETON
M_Ext-014 | COLUMN | Béton | 3 | 0.003 | 16.3089 | 16.3089 | 1.7782 | 1.2859 | 4267.62 | 3086.15 | Béton maquette archi | 0 STR BETON
4 x POTEAU-002 | COLUMN | Béton | 2.94 | 0.0005 | 4.66 | 4.66 | 0.3675 | 0.3675 | 882 | 882 | Béton maquette archi | 0 STR BETON
4 x POTEAU-002 | COLUMN | Béton | 2.19 | 0.0007 | 4.8 | 4.8 | 0.4599 | 0.4599 | 1103.76 | 1103.76 | Béton maquette archi | 0 STR BETON
2 x POTEAU-001 | COLUMN | Béton | 2.7 | 0.0004 | 3.6442 | 3.6442 | 0.432 | 0.3393 | 1036.8 | 814.3 | Béton maquette archi | 0 STR BETON
POTEAU-003 | COLUMN | Béton | 2.45 | 0.0007 | 5.005 | 5.005 | 0.4288 | 0.4287 | 1029 | 1029 | Béton maquette archi | 0 STR BETON
Poteau | COLUMN | GL24h | 2.8812 | 0.0003 | 3.1308 | 3.1309 | 0.1936 | 0.1936 | 73.5744 | 73.5744 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
POTEAU-002 | COLUMN | Béton | 2.94 | 0.0011 | 8.9963 | 8.9963 | 0.9844 | 0.9844 | 2362.56 | 2362.56 | Béton maquette archi | 0 STR BETON
M_Ext-016 | COLUMN | Béton | 2.05 | 0.0009 | 4.691 | 4.691 | 0.3782 | 0.3372 | 907.725 | 809.325 | Béton maquette archi | 0 STR BETON
4 x Diagonale |  | GL24h | 4.8571 | 0.0002 | 4.778 | 4.778 | 0.2798 | 0.2798 | 106.311 | 106.311 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+2
2 x Diagonale secondaire |  | GL24h | 3.6807 | 0.0003 | 4.0553 | 4.0553 | 0.2827 | 0.2651 | 107.418 | 100.753 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
2 x POTEAU-001 | COLUMN | Béton | 2.5 | 0.0004 | 4.0779 | 4.0779 | 0.3583 | 0.3583 | 859.84 | 859.84 | Béton maquette archi | 0 STR BETON
2 x Diagonale |  | GL24h | 3.8757 | 0.0002 | 3.8358 | 3.8358 | 0.2232 | 0.2232 | 84.8305 | 84.8305 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag | R+2
Poteau |  | GL24h | 3.4419 | 0.0003 | 4.0037 | 4.0037 | 0.2643 | 0.264 | 100.449 | 100.32 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt | R+2
M_Ext-013 | COLUMN | Béton | 3.2 | 0.0014 | 9.7829 | 9.7829 | 0.8706 | 0.7549 | 2089.48 | 1811.78 | Béton maquette archi | 0 STR BETON
2 x Poteau en V |  | GL24h | 8.8014 | 0.0006 | 15.9892 | 15.9892 | 1.6899 | 1.6276 | 642.151 | 618.504 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Pt(v) | R+0
4 x Diagonale |  | GL24h | 4.8414 | 0.0002 | 4.7629 | 4.7629 | 0.2789 | 0.2789 | 105.968 | 105.968 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+2
MUR_EXT-029 | COLUMN | Béton | 2.9 | 0.0016 | 6.549 | 6.549 | 0.928 | 0.3524 | 2227.2 | 845.7 | Béton maquette archi | 0 STR BETON
8 x Poteau | COLUMN | GL24h | 3.64 | 0.0003 | 3.92 | 3.92 | 0.2446 | 0.2446 | 92.951 | 92.951 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
M_Ext-011 | COLUMN | Béton | 2.9 | 0.0006 | 5.1771 | 5.1771 | 0.3758 | 0.3758 | 901.912 | 901.912 | Béton maquette archi | 0 STR BETON
Poteau | COLUMN | GL24h | 3.35 | 0.0003 | 3.9056 | 3.9056 | 0.2573 | 0.2573 | 97.7664 | 97.7664 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+2
2 x Diagonale |  | GL24h | 4.5255 | 0.0002 | 4.2505 | 4.2505 | 0.2607 | 0.2443 | 99.0542 | 92.8459 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+2
3 x Fourrure | COLUMN | GL24h | 3.05 | 0.0003 | 2.1742 | 2.1742 | 0.0598 | 0.0598 | 22.7163 | 22.7163 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+3
POTEAU-002 | COLUMN | Béton | 2.19 | 0.0005 | 3.804 | 3.804 | 0.3285 | 0.3285 | 788.4 | 788.4 | Béton maquette archi | 0 STR BETON
2 x Montant | COLUMN | GL24h | 3.37 | 0.0003 | 4.5184 | 4.5184 | 0.3451 | 0.3451 | 131.133 | 131.133 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
3 x Poteau | COLUMN | GL24h | 3.21 | 0.0003 | 3.752 | 3.752 | 0.2517 | 0.2517 | 95.6323 | 95.6323 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+1 | Cadwork3dProperties - Sous zone: Ruche
Diagonale secondaire |  | GL24h | 3.5426 | 0.0003 | 3.9453 | 3.9453 | 0.2721 | 0.2596 | 103.387 | 98.6348 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Diag sec | R+1
Poteau | COLUMN | GL24h | 3.4013 | 0.0002 | 3.3805 | 3.3805 | 0.1959 | 0.1959 | 74.4482 | 74.4482 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+3
2 x M_Ext-013 | COLUMN | Béton | 0.9874 | 0.0009 | 2.5505 | 2.5505 | 0.1792 | 0.1792 | 430.198 | 430.198 | Béton maquette archi | 0 STR BETON
Diagonale secondaire |  | GL24h | 3.5035 | 0.0003 | 3.9042 | 3.9042 | 0.2691 | 0.2568 | 102.247 | 97.5921 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Diag sec | R+1
2 x Diagonale |  | GL24h | 4.448 | 0.0002 | 4.2071 | 4.2071 | 0.2562 | 0.2435 | 97.358 | 92.5159 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+1
Béton | COLUMN | Béton | 1.3 | 0.0006 | 1.9426 | 1.9426 | 0.1451 | 0.1027 | 348.302 | 246.528 | Béton maquette archi | 0 STR BETON
10 x Diagonale secondaire |  | GL24h | 3.1973 | 0.0003 | 3.5801 | 3.5801 | 0.2456 | 0.2348 | 93.3098 | 89.2294 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
M_Ext-011 | COLUMN | Béton | 3.2 | 0.0013 | 10.4968 | 10.4968 | 1.2418 | 1.1535 | 2980.21 | 2768.32 | Béton maquette archi | 0 STR BETON
M_Ext-014 | COLUMN | Béton | 2.45 | 0.0022 | 12.313 | 12.313 | 1.078 | 1.029 | 2587.2 | 2469.6 | Béton maquette archi | 0 STR BETON
2 x Montant | COLUMN | GL24h | 3.15 | 0.0003 | 3.6816 | 3.6816 | 0.2419 | 0.2419 | 91.9296 | 91.9296 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
2 x M_Ext-012 | COLUMN | Béton | 2.45 | 0.0023 | 13.17 | 13.17 | 1.127 | 1.127 | 2704.8 | 2704.8 | Béton maquette archi | 0 STR BETON
Montant | COLUMN | GL24h | 3.37 | 0.0003 | 3.928 | 3.928 | 0.2588 | 0.2588 | 98.3501 | 98.3501 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
M_Ext-013 | COLUMN | Béton | 3 | 0.0028 | 19.4014 | 19.4014 | 1.7064 | 1.7064 | 4095.31 | 4095.31 | Béton maquette archi | 0 STR BETON
Diagonale |  | GL24h | 5.0797 | 0.0002 | 4.9917 | 4.9917 | 0.2926 | 0.2926 | 111.184 | 111.184 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+3
2 x Poteau en V |  | GL24h | 3.2954 | 0.0006 | 5.9638 | 5.9638 | 0.6327 | 0.5815 | 240.431 | 220.962 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
2 x POTEAU-002 | COLUMN | Béton | 2.2 | 0.0005 | 4.365 | 4.365 | 0.4455 | 0.4455 | 1069.21 | 1069.21 | Béton maquette archi | 0 STR BETON
M_Ext-011 | COLUMN | Béton | 2.45 | 0.0013 | 8.2055 | 8.2055 | 0.9507 | 0.8831 | 2281.73 | 2119.49 | Béton maquette archi | 0 STR BETON
3 x POTEAU-002 | COLUMN | Béton | 2.4164 | 0.0007 | 4.928 | 4.928 | 0.4229 | 0.4217 | 1014.9 | 1011.96 | Béton maquette archi | 0 STR BETON
10 x Poteau | COLUMN | GL24h | 3.31 | 0.0003 | 3.8608 | 3.8608 | 0.2542 | 0.2542 | 96.599 | 96.599 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+3
3 x POTEAU-002 | COLUMN | Béton | 2.2945 | 0.0005 | 4.253 | 4.253 | 0.413 | 0.4122 | 991.219 | 989.275 | Béton maquette archi | 0 STR BETON
M_Ext-012 | COLUMN | Béton | 3.2 | 0.0024 | 17.662 | 17.662 | 1.5418 | 1.5418 | 3700.4 | 3700.4 | Béton maquette archi | 0 STR BETON
POTEAU-002 | COLUMN | Béton | 2.2945 | 0.0005 | 4.5351 | 4.5351 | 0.4646 | 0.4646 | 1115.13 | 1115.13 | Béton maquette archi | 0 STR BETON
M_Ext-012 | COLUMN | Béton | 2.4504 | 0.0023 | 13.1619 | 13.1619 | 1.1272 | 1.1262 | 2705.2 | 2702.99 | Béton maquette archi | 0 STR BETON
Diagonale secondaire |  | GL24h | 3.5617 | 0.0003 | 3.9648 | 3.9648 | 0.2735 | 0.2608 | 103.945 | 99.111 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
POTEAU-001 | COLUMN | Béton | 2.4 | 0.0004 | 3.04 | 3.04 | 0.192 | 0.192 | 460.8 | 460.8 | Béton maquette archi | 0 STR BETON
3 x POTEAU-002 | COLUMN | Béton | 2.45 | 0.0005 | 3.925 | 3.925 | 0.3063 | 0.3063 | 735 | 735 | Béton maquette archi | 0 STR BETON
Poteau | COLUMN | GL24h | 3.4 | 0.0003 | 3.9648 | 3.9648 | 0.2666 | 0.2666 | 101.293 | 101.293 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+1 | Cadwork3dProperties - Sous zone: Ruche
Diagonale secondaire |  | GL24h | 3.5121 | 0.0003 | 3.9276 | 3.9276 | 0.2697 | 0.2598 | 102.496 | 98.7177 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
Poteau |  | GL24h | 3.3068 | 0.0003 | 4.1403 | 4.1403 | 0.2963 | 0.2958 | 112.588 | 112.389 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
POTEAU-002 | COLUMN | Béton | 2.94 | 0.0007 | 6.664 | 6.664 | 0.7203 | 0.7203 | 1728.73 | 1728.73 | Béton maquette archi | 0 STR BETON
POTEAU-002 | COLUMN | Béton | 2.94 | 0.0011 | 9.7 | 9.7 | 1.2936 | 1.2936 | 3104.64 | 3104.64 | Béton maquette archi | 0 STR BETON
2 x Poteau en V |  | GL24h | 5.1956 | 0.0006 | 9.3402 | 9.3402 | 0.9976 | 0.93 | 379.074 | 353.411 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
2 x Diagonale |  | GL24h | 5.1115 | 0.0002 | 5.0222 | 5.0222 | 0.2944 | 0.2944 | 111.88 | 111.88 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag | R+2
2 x Diagonale |  | GL24h | 4.2739 | 0.0003 | 4.6385 | 4.6385 | 0.3351 | 0.3068 | 127.328 | 116.584 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+1 | Cadwork3dProperties - Sous zone: Ruche
POTEAU-002 | COLUMN | Béton | 2.45 | 0.0005 | 4.22 | 4.22 | 0.3675 | 0.3675 | 882 | 882 | Béton maquette archi | 0 STR BETON
2 x POTEAU-003 | COLUMN | Béton | 2.45 | 0.0007 | 5.005 | 5.005 | 0.4287 | 0.4288 | 1029 | 1029 | Béton maquette archi | 0 STR BETON
Montant | COLUMN | GL24h | 3.37 | 0.0003 | 3.928 | 3.928 | 0.2588 | 0.2588 | 98.3501 | 98.3501 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
POTEAU-002 | COLUMN | Béton | 2.19 | 0.0011 | 6.8722 | 6.8722 | 0.7333 | 0.7333 | 1759.87 | 1759.87 | Béton maquette archi | 0 STR BETON
POTEAU-002 | COLUMN | Béton | 2.2 | 0.0007 | 4.53 | 4.53 | 0.385 | 0.385 | 924 | 924 | Béton maquette archi | 0 STR BETON
3 x POTEAU-002 | COLUMN | Béton | 2.2 | 0.0005 | 4.1 | 4.1 | 0.396 | 0.396 | 950.403 | 950.403 | Béton maquette archi | 0 STR BETON
POTEAU-002 | COLUMN | Béton | 2.2945 | 0.0005 | 4.527 | 4.527 | 0.4646 | 0.4637 | 1115.13 | 1112.94 | Béton maquette archi | 0 STR BETON
POTEAU-002 | COLUMN | Béton | 2.19 | 0.0007 | 5.089 | 5.089 | 0.5366 | 0.5366 | 1287.72 | 1287.72 | Béton maquette archi | 0 STR BETON
POTEAU-002 | COLUMN | Béton | 2.45 | 0.0004 | 3.3856 | 3.3856 | 0.2451 | 0.2451 | 588.168 | 588.168 | Béton maquette archi | 0 STR BETON
POTEAU-003 | COLUMN | Béton | 2.45 | 0.0007 | 5.005 | 5.005 | 0.4288 | 0.4288 | 1029 | 1029 | Béton maquette archi | 0 STR BETON
Poteau | COLUMN | GL24h | 3.64 | 0.0005 | 5.1852 | 5.1852 | 0.4656 | 0.3929 | 176.912 | 149.302 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
POTEAU-002 | COLUMN | Béton | 2.19 | 0.0011 | 7.45 | 7.45 | 0.9636 | 0.9636 | 2312.64 | 2312.64 | Béton maquette archi | 0 STR BETON
4 x Diagonale |  | GL24h | 4.7228 | 0.0002 | 4.6491 | 4.6491 | 0.272 | 0.272 | 103.372 | 103.372 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+1
2 x Diagonale |  | GL24h | 4.5261 | 0.0002 | 4.2155 | 4.2155 | 0.2607 | 0.2408 | 99.0667 | 91.5143 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Diag | R+2
POTEAU-002 | COLUMN | Béton | 2.3969 | 0.0007 | 4.8993 | 4.8993 | 0.4194 | 0.419 | 1006.68 | 1005.63 | Béton maquette archi | 0 STR BETON
3 x Diagonale |  | GL24h | 5.074 | 0.0002 | 4.9862 | 4.9862 | 0.2923 | 0.2923 | 111.059 | 111.059 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag | R+2
POTEAU-002 | COLUMN | Béton | 2.19 | 0.0005 | 3.535 | 3.535 | 0.2738 | 0.2738 | 657 | 657 | Béton maquette archi | 0 STR BETON
Diagonale |  | GL24h | 4.968 | 0.0002 | 4.8845 | 4.8845 | 0.2862 | 0.2862 | 108.741 | 108.741 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+3
2 x Diagonale |  | GL24h | 4.2213 | 0.0003 | 4.5843 | 4.5843 | 0.331 | 0.3032 | 125.761 | 115.22 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+2 | Cadwork3dProperties - Sous zone: Ruche
Béton | COLUMN | Béton | 2.9 | 0.0022 | 14.3251 | 14.3251 | 1.2671 | 1.2091 | 3041.03 | 2901.83 | Béton maquette archi | 0 STR BETON
POTEAU-002 | COLUMN | Béton | 2.94 | 0.0007 | 6.6952 | 6.6953 | 0.7291 | 0.7291 | 1749.92 | 1749.92 | Béton maquette archi | 0 STR BETON
M_Ext-012 | COLUMN | Béton | 2.6913 | 0.0023 | 14.3765 | 14.3765 | 1.238 | 1.238 | 2971.21 | 2971.21 | Béton maquette archi | 0 STR BETON
M_Ext-014 | COLUMN | Béton | 2.45 | 0.0023 | 12.6345 | 12.6345 | 1.1077 | 1.0587 | 2658.56 | 2540.95 | Béton maquette archi | 0 STR BETON
4 x Montant | COLUMN | GL24h | 5.19 | 0.0003 | 6.848 | 6.848 | 0.5315 | 0.5315 | 201.953 | 201.953 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Mt | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
Montant | COLUMN | GL24h | 3.37 | 0.0003 | 4.5184 | 4.5184 | 0.3451 | 0.3451 | 131.133 | 131.133 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
Poteau en V |  | GL24h | 3.3606 | 0.0006 | 5.9644 | 5.9644 | 0.6452 | 0.579 | 245.192 | 220.011 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
Béton | COLUMN | Béton | 3.13 | 0.0017 | 11.8653 | 11.8653 | 1.0358 | 0.9732 | 2485.94 | 2335.7 | Béton maquette archi | 0 STR BETON
Montant | COLUMN | GL24h | 4.37 | 0.0003 | 5.7984 | 5.7984 | 0.4475 | 0.4475 | 170.045 | 170.045 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Mt | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
Poteau en V |  | GL24h | 3.2186 | 0.0006 | 5.6901 | 5.6901 | 0.618 | 0.5486 | 234.828 | 208.455 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
M_Ext-012 | COLUMN | Béton | 3.2 | 0.0014 | 10.5178 | 10.5178 | 0.9085 | 0.8445 | 2180.37 | 2026.77 | Béton maquette archi | 0 STR BETON
M_Ext-012 | COLUMN | Béton | 3.2 | 0.0028 | 19.9256 | 19.9256 | 2.6483 | 2.3603 | 6355.84 | 5664.68 | Béton maquette archi | 0 STR BETON
M_Ext-012 | COLUMN | Béton | 3.2 | 0.0029 | 22.5697 | 22.5697 | 3.0088 | 2.9832 | 7221.03 | 7159.62 | Béton maquette archi | 0 STR BETON
M_Ext-012 | COLUMN | Béton | 2.45 | 0.0014 | 8.1764 | 8.1764 | 0.6956 | 0.6466 | 1669.35 | 1551.75 | Béton maquette archi | 0 STR BETON
M_Ext-012 | COLUMN | Béton | 2.2 | 0.0007 | 4.0368 | 4.0368 | 0.3167 | 0.2727 | 759.998 | 654.398 | Béton maquette archi | 0 STR BETON
M_Ext-012 | COLUMN | Béton | 2.6439 | 0.0007 | 4.8013 | 4.8013 | 0.3806 | 0.3277 | 913.338 | 786.432 | Béton maquette archi | 0 STR BETON
Diagonale secondaire |  | GL24h | 5.0807 | 0.0003 | 5.844 | 5.844 | 0.3902 | 0.3902 | 148.276 | 148.276 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
POTEAU-001 | COLUMN | Béton | 2.5 | 0.0004 | 4.0805 | 4.0805 | 0.3587 | 0.3587 | 860.884 | 860.884 | Béton maquette archi | 0 STR BETON
2 x Diagonale secondaire |  | GL24h | 5.1115 | 0.0003 | 5.8784 | 5.8784 | 0.3926 | 0.3926 | 149.173 | 149.173 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
Poteau |  | GL24h | 3.5782 | 0.0003 | 4.1563 | 4.1563 | 0.2748 | 0.2745 | 104.425 | 104.297 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt | R+2
Poteau |  | GL24h | 3.5887 | 0.0003 | 4.1692 | 4.1692 | 0.2756 | 0.2754 | 104.732 | 104.635 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt | R+2
Poteau | COLUMN | GL24h | 3.37 | 0.0002 | 3.3504 | 3.3504 | 0.1941 | 0.1941 | 73.7626 | 73.7626 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+1
2 x Diagonale |  | GL24h | 4.6812 | 0.0002 | 4.6092 | 4.6092 | 0.2696 | 0.2696 | 102.462 | 102.462 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag | R+2
4 x Poteau | COLUMN | GL24h | 5.03 | 0.0003 | 5.7904 | 5.7904 | 0.3944 | 0.3944 | 149.854 | 149.854 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+3 | Cadwork3dProperties - Sous zone: Ruche
M_Ext-012 | COLUMN | Béton | 2.45 | 0.0024 | 13.7483 | 13.7483 | 1.1805 | 1.1805 | 2833.12 | 2833.12 | Béton maquette archi | 0 STR BETON
M_Ext-013 | COLUMN | Béton | 2.7 | 0.0009 | 5.9915 | 5.9915 | 0.4905 | 0.4365 | 1177.09 | 1047.49 | Béton maquette archi | 0 STR BETON
2 x Diagonale |  | GL24h | 4.6841 | 0.0003 | 5.3324 | 5.3324 | 0.3672 | 0.3618 | 139.549 | 137.489 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+1 | Cadwork3dProperties - Sous zone: Ruche
M_Ext-013 | COLUMN | Béton | 3 | 0.003 | 20.2837 | 20.2837 | 1.7891 | 1.7891 | 4293.84 | 4293.84 | Béton maquette archi | 0 STR BETON
M_Ext-018 | COLUMN | Béton | 2.05 | 0.0009 | 4.691 | 4.691 | 0.3782 | 0.3372 | 907.725 | 809.325 | Béton maquette archi | 0 STR BETON
M_Ext-013 | COLUMN | Béton | 3.2 | 0.0024 | 16.7702 | 16.7702 | 1.536 | 1.408 | 3686.4 | 3379.2 | Béton maquette archi | 0 STR BETON
MUR_EXT-029 | COLUMN | Béton | 2.9 | 0.0021 | 7.1022 | 7.1022 | 1.2381 | 0.3423 | 2971.4 | 821.575 | Béton maquette archi | 0 STR BETON
M_Ext-013 | COLUMN | Béton | 2.9 | 0.0004 | 3.64 | 3.64 | 0.232 | 0.232 | 556.8 | 556.8 | Béton maquette archi | 0 STR BETON
MUR_EXT-029 | COLUMN | Béton | 2.9 | 0.0024 | 15.6696 | 15.6696 | 1.3835 | 1.348 | 3320.46 | 3235.12 | Béton maquette archi | 0 STR BETON
6 x Poteau en V |  | GL24h | 3.3801 | 0.0006 | 6.1283 | 6.1284 | 0.649 | 0.5953 | 246.611 | 226.203 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
M_Ext-013 | COLUMN | Béton | 2.9 | 0.0025 | 13.1622 | 13.1622 | 1.4471 | 1.0148 | 3473.04 | 2435.57 | Béton maquette archi | 0 STR BETON
M_Ext-013 | COLUMN | Béton | 2.45 | 0.0024 | 13.0459 | 13.0459 | 1.176 | 1.078 | 2822.4 | 2587.2 | Béton maquette archi | 0 STR BETON
M_Ext-015 | COLUMN | Béton | 2.7 | 0.0007 | 4.8283 | 4.8283 | 0.3822 | 0.3282 | 917.18 | 787.58 | Béton maquette archi | 0 STR BETON
Béton | COLUMN | Béton | 2.9 | 0.0006 | 4.1391 | 4.1391 | 0.3237 | 0.2291 | 776.981 | 549.947 | Béton maquette archi | 0 STR BETON
M_Ext-014 | COLUMN | Béton | 0.9496 | 0.0007 | 1.8833 | 1.8833 | 0.1367 | 0.1177 | 328.04 | 282.46 | Béton maquette archi | 0 STR BETON
M_Ext-020 | COLUMN | Béton | 3.2 | 0.0021 | 15.2928 | 15.2928 | 1.3189 | 1.3189 | 3165.3 | 3165.24 | Béton maquette archi | 0 STR BETON
M_Ext-016 | COLUMN | Béton | 3.2 | 0.0029 | 20.9383 | 20.9383 | 1.8754 | 1.8428 | 4500.98 | 4422.83 | Béton maquette archi | 0 STR BETON
M_Ext-014 | COLUMN | Béton | 2.9 | 0.0025 | 16.629 | 16.629 | 1.4471 | 1.4471 | 3473.04 | 3473.04 | Béton maquette archi | 0 STR BETON
M_Ext-016 | COLUMN | Béton | 2.45 | 0.0022 | 8.1481 | 8.1481 | 1.0718 | 0.5626 | 2572.21 | 1350.18 | Béton maquette archi | 0 STR BETON
M_Ext-016 | COLUMN | Béton | 3.2 | 0.0022 | 10.6122 | 10.6122 | 1.408 | 0.7387 | 3379.2 | 1772.91 | Béton maquette archi | 0 STR BETON
2 x Diagonale secondaire |  | GL24h | 3.6996 | 0.0003 | 4.2972 | 4.2972 | 0.2841 | 0.2841 | 107.97 | 107.97 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
M_Ext-014 | COLUMN | Béton | 3.2 | 0.0023 | 16.2377 | 16.2377 | 1.4468 | 1.3828 | 3472.4 | 3318.8 | Béton maquette archi | 0 STR BETON
Poteau en V |  | GL24h | 8.9685 | 0.0006 | 16.4184 | 16.4184 | 1.722 | 1.6735 | 654.342 | 635.914 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Pt(v) | R+0
M_Ext-014 | COLUMN | Béton | 3.2 | 0.0018 | 13.4886 | 13.4886 | 1.149 | 1.149 | 2757.72 | 2757.72 | Béton maquette archi | 0 STR BETON
MUR_EXT-029 | COLUMN | Béton | 2.9 | 0.0017 | 11.3202 | 11.3202 | 0.986 | 0.928 | 2366.4 | 2227.2 | Béton maquette archi | 0 STR BETON
M_Ext-014 | COLUMN | Béton | 1.3935 | 0.0007 | 2.6478 | 2.6478 | 0.2006 | 0.1727 | 481.38 | 414.494 | Béton maquette archi | 0 STR BETON
M_Ext-015 | COLUMN | Béton | 2.6439 | 0.0025 | 9.8896 | 9.8896 | 1.3325 | 0.6966 | 3198.04 | 1671.81 | Béton maquette archi | 0 STR BETON
M_Ext-014 | COLUMN | Béton | 2.45 | 0.0018 | 10.4956 | 10.4956 | 0.8797 | 0.8797 | 2111.38 | 2111.38 | Béton maquette archi | 0 STR BETON
M_Ext-016 | COLUMN | Béton | 2.45 | 0.0022 | 7.1001 | 7.1001 | 1.078 | 0.4237 | 2587.2 | 1016.91 | Béton maquette archi | 0 STR BETON
M_Ext-016 | COLUMN | Béton | 3.2 | 0.0028 | 20.2028 | 20.2028 | 1.7946 | 1.7793 | 4307.06 | 4270.22 | Béton maquette archi | 0 STR BETON
M_Ext-016 | COLUMN | Béton | 3.2 | 0.0022 | 11.6094 | 11.6094 | 1.3998 | 0.8721 | 3359.62 | 2092.96 | Béton maquette archi | 0 STR BETON
Poteau | COLUMN | GL24h | 3.42 | 0.0003 | 3.6912 | 3.6912 | 0.2298 | 0.2298 | 87.3331 | 87.3331 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Pt | R+1
Poteau en V |  | GL24h | 6.5706 | 0.0006 | 11.7129 | 11.7129 | 1.2615 | 1.1746 | 479.388 | 446.331 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
Poteau | COLUMN | GL24h | 3.35 | 0.0003 | 3.6184 | 3.6184 | 0.2251 | 0.2251 | 85.5456 | 85.5456 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+2

Properties of the parts of a building model (IFC4), part 3 of 4

# IfcColumn (694)
Name | PredefinedType | Material | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | NetSurfaceArea (m2) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg) | Group | Repérage ensemble | Bâtiment | Nom export 2d | Niveaux
Poteau | COLUMN | GL24h | 3.35 | 0.0002 | 3.3312 | 3.3312 | 0.193 | 0.193 | 73.3248 | 73.3248 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Pt | R+2
Diagonale |  | GL24h | 5.0646 | 0.0002 | 4.9772 | 4.9772 | 0.2917 | 0.2917 | 110.855 | 110.855 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+3
2 x Poteau en V |  | GL24h | 5.182 | 0.0006 | 9.3136 | 9.3136 | 0.9949 | 0.9271 | 378.079 | 352.293 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
Poteau | COLUMN | GL24h | 2.91 | 0.0003 | 2.9056 | 2.9056 | 0.163 | 0.163 | 61.9248 | 61.9248 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+0 | Cadwork3dProperties - Sous zone: Ruche
Poteau | COLUMN | GL24h | 2.8674 | 0.0002 | 2.8679 | 2.8679 | 0.1652 | 0.1652 | 62.7616 | 62.7616 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
Poteau | COLUMN | GL24h | 2.7374 | 0.0003 | 3.2195 | 3.2195 | 0.2102 | 0.2102 | 79.8882 | 79.8882 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
Poteau | COLUMN | GL24h | 3.0068 | 0.0003 | 3.2615 | 3.2615 | 0.2021 | 0.2021 | 76.7826 | 76.7826 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
Montant |  | GL24h | 3.67 | 0.0003 | 4.264 | 4.264 | 0.2819 | 0.2819 | 107.105 | 107.105 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
Poteau | COLUMN | GL24h | 3.64 | 0.0005 | 5.1844 | 5.1844 | 0.4654 | 0.3928 | 176.853 | 149.273 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
Poteau | COLUMN | GL24h | 2.8674 | 0.0003 | 3.3651 | 3.3651 | 0.2202 | 0.2202 | 83.6821 | 83.6821 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
Poteau | COLUMN | GL24h | 5.31 | 0.0003 | 6.104 | 6.104 | 0.4163 | 0.4163 | 158.196 | 158.196 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+0 | Cadwork3dProperties - Sous zone: Ruche
Poteau | COLUMN | GL24h | 5.19 | 0.0003 | 5.9696 | 5.9696 | 0.4069 | 0.4069 | 154.62 | 154.62 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+0 | Cadwork3dProperties - Sous zone: Ruche
Poteau | COLUMN | GL24h | 3.37 | 0.0002 | 3.3504 | 3.3504 | 0.1941 | 0.1941 | 73.7626 | 73.7626 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Pt | R+1
Poteau | COLUMN | GL24h | 3.37 | 0.0003 | 3.928 | 3.928 | 0.2588 | 0.2588 | 98.3501 | 98.3501 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Pt | R+1
Poteau | COLUMN | GL24h | 3.37 | 0.0003 | 3.6392 | 3.6392 | 0.2265 | 0.2265 | 86.0563 | 86.0563 | Charpente L.C. | A1 Hall | Bât A Autre Bâtiment | Pt | R+1
Poteau | COLUMN | GL24h | 3.42 | 0.0003 | 3.9872 | 3.9872 | 0.2681 | 0.2681 | 101.889 | 101.889 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Pt | R+1 | Cadwork3dProperties - Sous zone: Ruche
Poteau en V |  | GL24h | 5.4607 | 0.0006 | 9.9302 | 9.9302 | 1.0484 | 0.9947 | 398.409 | 377.99 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
2 x Diagonale |  | GL24h | 4.2213 | 0.0003 | 4.5843 | 4.5843 | 0.331 | 0.3032 | 125.761 | 115.22 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+3 | Cadwork3dProperties - Sous zone: Ruche
2 x Diagonale |  | GL24h | 4.7257 | 0.0003 | 4.686 | 4.686 | 0.3024 | 0.2753 | 114.929 | 104.61 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Diag | R+1
Poteau en V |  | GL24h | 5.4848 | 0.0006 | 9.968 | 9.968 | 1.0531 | 0.9985 | 400.173 | 379.441 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
Diagonale secondaire |  | GL24h | 5.0616 | 0.0003 | 5.8226 | 5.8226 | 0.3887 | 0.3887 | 147.718 | 147.718 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Diag sec | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
Montant | COLUMN | GL24h | 3.37 | 0.0005 | 4.8166 | 4.8166 | 0.431 | 0.3638 | 163.789 | 138.227 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Mt | R+1 | Cadwork3dProperties - Sous zone: Poutre treillis
2 x Poteau | COLUMN | GL24h | 2.7709 | 0.0003 | 3.0161 | 3.0161 | 0.1862 | 0.1862 | 70.7568 | 70.7568 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
Poteau |  | GL24h | 3.3842 | 0.0003 | 4.2349 | 4.2349 | 0.3032 | 0.3028 | 115.224 | 115.073 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
Poteau | COLUMN | GL24h | 3.0709 | 0.0003 | 3.593 | 3.593 | 0.2358 | 0.2358 | 89.6201 | 89.6201 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
Poteau | COLUMN | GL24h | 3.0752 | 0.0003 | 3.5954 | 3.5954 | 0.2362 | 0.236 | 89.7461 | 89.6831 | Charpente L.C. | 2 A2 Salles | Bât B Learning center | Pt | R+2
2 x Diagonale |  | GL24h | 4.2374 | 0.0003 | 4.6023 | 4.6023 | 0.3322 | 0.3045 | 126.241 | 115.7 | Charpente L.C. | A3 Ruche | Bât A Autre Bâtiment | Diag | R+1 | Cadwork3dProperties - Sous zone: Ruche
Poteau en V |  | GL24h | 3.509 | 0.0006 | 6.3009 | 6.3009 | 0.6737 | 0.612 | 256.017 | 232.571 | Charpente L.C. | 2 A1 Préau | Bât B Learning center | Pt(v) | R+0 | Cadwork3dProperties - Sous zone: Poutre treillis
Diagonale |  | GL24h | 5.0786 | 0.0002 | 4.9907 | 4.9907 | 0.2925 | 0.2925 | 111.161 | 111.161 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+3
Diagonale secondaire |  | GL24h | 3.1406 | 0.0003 | 3.514 | 3.514 | 0.2412 | 0.2301 | 91.6562 | 87.448 | Charpente L.C. | 2 A1 Préau | Bât A Autre Bâtiment | Diag sec | R+1
Diagonale |  | GL24h | 4.9445 | 0.0002 | 4.862 | 4.862 | 0.2848 | 0.2848 | 108.226 | 108.226 | Charpente L.C. | A2 Salles | Bât A Autre Bâtiment | Diag | R+3
Diagonale secondaire |  | GL24h | 3.1698 | 0.0003 | 3.5485 | 3.5485 | 0.2434 | 0.2326 | 92.5087 | 88.3811 | Charpente L.C. | 2 A1 Préau | Bât A Autre Bâtiment | Diag sec | R+1

# IfcMember (1220)
In: Storey 1
Name | Material | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | NetSurfaceArea (m2) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg) | Group | Bâtiment | Repérage ensemble | Niveaux
17 x Support allège | C24 | 3.18 | 0.0001 | 1.0602 | 1.0602 | 0.0172 | 0.0172 | 6.0102 | 6.0102 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
14 x Marche | GL24h | 2.1 | 0 | 1.3622 | 1.3622 | 0.0103 | 0.0103 | 3.907 | 3.907 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche
17 x Précadre | C24 | 3 | 0.0001 | 0.513 | 0.513 | 0.0045 | 0.0045 | 1.575 | 1.575 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
39 x Lièrne BLC | GL24h | 3.66 | 0.0002 | 2.5448 | 2.5448 | 0.1025 | 0.1025 | 38.9424 | 38.9424 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Li
20 x Contre marche | GL24h | 1.52 | 0 | 0.5064 | 0.5064 | 0.0036 | 0.0036 | 1.377 | 1.377 | Escalier | Bât B Learning center | C1 Escalier | R+1
2 x Planche CF | C24 | 23.28 | 0.0002 | 13.5264 | 13.5264 | 0.2794 | 0.2794 | 97.776 | 97.776 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+2
46 x Précadre | C24 | 1.48 | 0.0001 | 0.3449 | 0.3449 | 0.0033 | 0.0033 | 1.1655 | 1.1655 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1 | PredefinedType: STUD
18 x Marche | GL24h | 2.1 | 0 | 1.2775 | 1.2776 | 0.0096 | 0.0096 | 3.6516 | 3.6516 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche
18 x Nervure | GL24h | 8.3503 | 0.0004 | 8.7047 | 8.7047 | 0.481 | 0.4736 | 182.771 | 179.951 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
7 x Contre marche | GL24h | 2.4503 | 0 | 0.7746 | 0.7746 | 0.0055 | 0.0055 | 2.1027 | 2.1027 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
2 x Précadre | C24 | 0.8877 | 0.0001 | 0.1539 | 0.1539 | 0.0013 | 0.0013 | 0.466 | 0.466 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
21 x Lièrne BLC | GL24h | 3.66 | 0.0002 | 2.5448 | 2.5448 | 0.1025 | 0.1025 | 38.9424 | 38.9424 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Li
Muraillère sur beton | GL24h | 4.34 | 0.0002 | 3.0072 | 3.0072 | 0.1215 | 0.1215 | 46.1776 | 46.1776 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration; Nom export 2d: Mu
32 x Précadre | C24 | 1.48 | 0.0001 | 0.3449 | 0.3449 | 0.0033 | 0.0033 | 1.1655 | 1.1655 | MOB/FOB | Bât B Learning center | 2 B1 MOB 360 | R+2 | PredefinedType: STUD
2 x Support allège | C24 | 1.13 | 0.0001 | 0.3837 | 0.3837 | 0.0061 | 0.0061 | 2.1357 | 2.1357 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
21 x Contre marche | GL24h | 2.1 | 0 | 0.6645 | 0.6645 | 0.0047 | 0.0047 | 1.8021 | 1.8021 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche
Lièrne BLC | GL24h | 28.1478 | 0.0002 | 19.1757 | 19.1757 | 0.7881 | 0.7871 | 299.493 | 299.114 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Nom export 2d: Li
5 x Muraillère | GL24h | 8.02 | 0.0002 | 4.2024 | 4.2024 | 0.1283 | 0.1283 | 48.7616 | 48.7616 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
Planche CF | C24 | 14.3173 | 0.0001 | 5.1533 | 5.1533 | 0.0802 | 0.08 | 28.0619 | 27.992 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
4 x Muraillère | GL24h | 8.06 | 0.0002 | 4.2232 | 4.2232 | 0.129 | 0.129 | 49.0048 | 49.0048 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
Lièrne BLC | GL24h | 32.1661 | 0.0002 | 21.9081 | 21.9081 | 0.9006 | 0.8997 | 342.247 | 341.868 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Nom export 2d: Li
VOLEE-036 | Béton | 2.7005 | 0.0014 | 10.3227 | 10.3227 | 1.1143 | 0.8159 | 2674.34 | 1958.23 | Béton maquette archi |  | 0 STR BETON
56 x Précadre | C24 | 1.48 | 0.0001 | 0.3449 | 0.3449 | 0.0033 | 0.0033 | 1.1655 | 1.1655 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3 | PredefinedType: STUD
Plat | Acier S235 | 2.665 | 0.0002 | 1.3159 | 1.3159 | 0.0063 | 0.0063 | 49.3718 | 49.3718 | Charpente metallique | Bât A Autre Bâtiment |  | R+0 | Cadwork3dProperties - Sous zone: Ruche
12 x Nervure | GL24h | 8.3504 | 0.0004 | 8.7059 | 8.7059 | 0.481 | 0.4736 | 182.773 | 179.987 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
14 x Contre marche | GL24h | 2.44 | 0 | 0.7714 | 0.7714 | 0.0055 | 0.0055 | 2.0939 | 2.0939 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
42 x Lièrne BLC | GL24h | 3.66 | 0.0002 | 2.5448 | 2.5448 | 0.1025 | 0.1025 | 38.9424 | 38.9424 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Li
17 x Support allège | C24 | 3.18 | 0.0001 | 1.0602 | 1.0602 | 0.0172 | 0.0172 | 6.0102 | 6.0102 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
8 x Nervure | GL24h | 8.075 | 0.0004 | 8.5017 | 8.5017 | 0.4651 | 0.4645 | 176.746 | 176.502 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
18 x Nervure | GL24h | 8.3549 | 0.0004 | 8.7091 | 8.7091 | 0.4812 | 0.4738 | 182.871 | 180.056 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
9 x Marche | GL24h | 2.1 | 0 | 1.3622 | 1.3622 | 0.0103 | 0.0103 | 3.907 | 3.907 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche
48 x Précadre | C24 | 1.48 | 0.0001 | 0.3449 | 0.3449 | 0.0033 | 0.0033 | 1.1655 | 1.1655 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2 | PredefinedType: STUD
Limon | Acier S235 | 3.4606 | 0.0004 | 7.5271 | 7.5271 | 0.0398 | 0.0378 | 312.142 | 297.024 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
6 x Contre marche | GL24h | 5.82 | 0 | 3.8546 | 3.8546 | 0.0293 | 0.0293 | 11.1212 | 11.1212 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Marche | GL24h | 5.82 | 0 | 6.7715 | 6.7715 | 0.0532 | 0.0525 | 20.2203 | 19.948 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
9 x Marche | GL24h | 2.1 | 0 | 1.2775 | 1.2776 | 0.0096 | 0.0096 | 3.6516 | 3.6516 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche
8 x Poteau | GL24h | 3.3 | 0.0002 | 2.4408 | 2.4408 | 0.1069 | 0.1069 | 40.6296 | 40.6296 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
Muraillère | GL24h | 2.7378 | 0.0002 | 1.4308 | 1.4308 | 0.0438 | 0.0429 | 16.6456 | 16.3093 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
VOLEE-036 | Béton | 2.4628 | 0.0014 | 9.3894 | 9.3894 | 1.0118 | 0.7417 | 2428.33 | 1780.01 | Béton maquette archi |  | 0 STR BETON
2 x Muraillère | GL24h | 2.4544 | 0.0002 | 1.3083 | 1.3083 | 0.0393 | 0.0393 | 14.9226 | 14.9226 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Planche CF | C24 | 21.473 | 0.0002 | 10.7323 | 10.7323 | 0.2147 | 0.2142 | 75.1555 | 74.9773 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
15 x Support allège | C24 | 3.18 | 0.0001 | 1.0602 | 1.0602 | 0.0172 | 0.0172 | 6.0102 | 6.0102 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
10 x Nervure | GL24h | 8.3592 | 0.0005 | 10.7592 | 10.7592 | 0.642 | 0.6348 | 243.954 | 241.211 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
13 x Marche | GL24h | 2.44 | 0 | 1.5601 | 1.5601 | 0.0118 | 0.0118 | 4.476 | 4.476 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
4 x Planche CF | C24 | 23.4 | 0.0002 | 11.72 | 11.72 | 0.234 | 0.234 | 81.9 | 81.9 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+1
Marche | GL24h | 6.38 | 0 | 38.5629 | 38.5629 | 0.4227 | 0.3058 | 160.611 | 116.208 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
4 x Planche CF | C24 | 23.4 | 0.0002 | 11.72 | 11.72 | 0.234 | 0.234 | 81.9 | 81.9 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+2
VOLEE-035 | Béton | 2.5989 | 0.0014 | 9.6794 | 9.6794 | 1.0724 | 0.7367 | 2573.66 | 1768.18 | Béton maquette archi |  | 0 STR BETON
Muraillère | GL24h | 2.7096 | 0.0001 | 1.3286 | 1.3286 | 0.0379 | 0.0379 | 14.4148 | 14.4148 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
3 x Support allège | C24 | 2.16 | 0.0001 | 0.7236 | 0.7236 | 0.0117 | 0.0117 | 4.0824 | 4.0824 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
Support allège | C24 | 1.0675 | 0.0001 | 0.3631 | 0.3631 | 0.0058 | 0.0058 | 2.0175 | 2.0175 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Poteau | GL24h | 2.79 | 0.0002 | 2.312 | 2.312 | 0.1116 | 0.1116 | 42.408 | 42.408 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
Marche | GL24h | 2.1 | 0 | 1.2399 | 1.2399 | 0.0093 | 0.0093 | 3.5381 | 3.5381 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche
17 x Précadre | C24 | 3 | 0.0001 | 0.513 | 0.513 | 0.0045 | 0.0045 | 1.575 | 1.575 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Muraillère | GL24h | 8.0733 | 0.0002 | 4.2268 | 4.2268 | 0.1292 | 0.1291 | 49.0859 | 49.046 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
19 x Contre marche | GL24h | 2.1 | 0 | 0.6766 | 0.6766 | 0.0048 | 0.0048 | 1.8386 | 1.8386 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche
7 x Marche | GL24h | 2.4503 | 0 | 1.5667 | 1.5667 | 0.0118 | 0.0118 | 4.4949 | 4.4949 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
2 x Muraillère | GL24h | 34.77 | 0.0002 | 18.1124 | 18.1124 | 0.5563 | 0.5563 | 211.402 | 211.402 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
3 x Lièrne BLC | GL24h | 3.78 | 0.0002 | 2.6264 | 2.6264 | 0.1058 | 0.1058 | 40.2192 | 40.2192 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Li
8 x Nervure | GL24h | 8.0815 | 0.0004 | 8.5047 | 8.5047 | 0.4655 | 0.4646 | 176.888 | 176.565 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
3 x Précadre | C24 | 1.98 | 0.0001 | 0.3396 | 0.3396 | 0.003 | 0.003 | 1.0395 | 1.0395 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
3 x Précadre | C24 | 0.8877 | 0.0001 | 0.1539 | 0.1539 | 0.0013 | 0.0013 | 0.466 | 0.466 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
Muraillère sur beton | GL24h | 9.2778 | 0.0005 | 11.931 | 11.931 | 0.7125 | 0.7048 | 270.763 | 267.835 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration; Nom export 2d: Mu
20 x Marche | GL24h | 1.52 | 0 | 0.9887 | 0.9887 | 0.0074 | 0.0074 | 2.8279 | 2.8279 | Escalier | Bât B Learning center | C1 Escalier | R+1
8 x Poteau | GL24h | 1.4 | 0.0002 | 0.9472 | 0.9472 | 0.0358 | 0.0358 | 13.6192 | 13.6192 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+4 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
2 x Muraillère | GL24h | 2.39 | 0.0002 | 1.2748 | 1.2748 | 0.0382 | 0.0382 | 14.5312 | 14.5312 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
15 x Contre marche | GL24h | 2.1 | 0 | 0.666 | 0.666 | 0.0048 | 0.0048 | 1.8067 | 1.8067 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche
2 x Suspente | Acier S235 | 0.1041 | 0 | 0.0236 | 0.0236 | 0.0001 | 0 | 0.4551 | 0.3496 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche; PredefinedType: STUD
4 x Précadre | C24 | 0.9399 | 0.0001 | 0.1628 | 0.1628 | 0.0014 | 0.0014 | 0.4934 | 0.4934 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
Contre marche | GL24h | 5.82 | 0 | 3.6678 | 3.6678 | 0.0278 | 0.0278 | 10.555 | 10.555 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
2 x Poutre | GL24h | 8.075 | 0.0004 | 9.8495 | 9.8495 | 0.6977 | 0.6967 | 265.119 | 264.753 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Muraillère | GL24h | 1.99 | 0.0002 | 1.0668 | 1.0668 | 0.0318 | 0.0318 | 12.0992 | 12.0992 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
4 x Support allège | C24 | 2.16 | 0.0001 | 0.7236 | 0.7236 | 0.0117 | 0.0117 | 4.0824 | 4.0824 | MOB/FOB | Bât B Learning center | 2 B1 MOB 360 | R+2
15 x Précadre | C24 | 3 | 0.0001 | 0.513 | 0.513 | 0.0045 | 0.0045 | 1.575 | 1.575 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
Nervure | GL24h | 6.7457 | 0.0005 | 8.7416 | 8.7416 | 0.5181 | 0.5145 | 196.865 | 195.518 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Muraillère | GL24h | 8.119 | 0.0003 | 6.8734 | 6.8734 | 0.2598 | 0.2594 | 98.7271 | 98.5731 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
5 x Limon | GL24h | 3.8509 | 0.0006 | 5.3086 | 5.3086 | 0.4621 | 0.3469 | 175.601 | 131.815 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
Marche | GL24h | 3.94 | 0 | 1.0755 | 1.0755 | 0.0076 | 0.0076 | 2.8746 | 2.8746 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
12 x Support allège | C24 | 3.18 | 0.0001 | 1.0602 | 1.0602 | 0.0172 | 0.0172 | 6.0102 | 6.0102 | MOB/FOB | Bât B Learning center | 2 B1 MOB 360 | R+2
2 x Poteau | Acier S235 | 2.6736 | 0.0002 | 3.0815 | 3.0815 | 0.0061 | 0.0062 | 47.8568 | 48.6664 | Charpente metallique | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
2 x Poteau | GL24h | 2.95 | 0.0002 | 2.1888 | 2.1888 | 0.0956 | 0.0956 | 36.3204 | 36.3204 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
Muraillère | GL24h | 8.1088 | 0.0002 | 4.246 | 4.246 | 0.1297 | 0.1297 | 49.3018 | 49.2716 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
2 x Plat | Acier S235 | 3.1228 | 0 | 0.5381 | 0.5381 | 0.0015 | 0.0015 | 11.773 | 11.7668 | Escalier | Bât A Autre Bâtiment |  | R+2 | Cadwork3dProperties - Sous zone: Ruche
2 x Muraillère | GL24h | 2.0744 | 0.0001 | 1.0237 | 1.0237 | 0.029 | 0.029 | 11.0357 | 11.0357 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Muraillère | GL24h | 8.0688 | 0.0002 | 4.2252 | 4.2252 | 0.1291 | 0.129 | 49.0585 | 49.0283 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
2 x Traverse | Acier S235 | 2.1 | 0.0002 | 2.4214 | 2.4214 | 0.0048 | 0.0049 | 37.59 | 38.2259 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Tra
3 x Précadre | C24 | 1.98 | 0.0001 | 0.3396 | 0.3396 | 0.003 | 0.003 | 1.0395 | 1.0395 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
2 x Muraillère | GL24h | 2.3961 | 0.0002 | 1.2754 | 1.2754 | 0.0383 | 0.0383 | 14.5683 | 14.5382 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
6 x Arbalétrier | GL24h | 6.4103 | 0.0007 | 10.2975 | 10.2975 | 0.821 | 0.6939 | 311.993 | 263.673 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+4 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Arb
Muraillère | GL24h | 20.1235 | 0.0002 | 10.4776 | 10.4776 | 0.322 | 0.3213 | 122.351 | 122.089 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
Précadre | C24 | 2.4 | 0.0001 | 0.411 | 0.411 | 0.0036 | 0.0036 | 1.26 | 1.26 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
Muraillère | GL24h | 3.9 | 0.0002 | 2.06 | 2.06 | 0.0624 | 0.0624 | 23.712 | 23.712 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
Contre marche | GL24h | 3.1457 | 0 | 7.4249 | 7.4249 | 0.0941 | 0.0581 | 35.7596 | 22.0837 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
27 x Nervure | GL24h | 8.3552 | 0.0004 | 8.7073 | 8.7073 | 0.4813 | 0.4737 | 182.879 | 179.998 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
4 x Nervure | GL24h | 9.2778 | 0.0005 | 11.931 | 11.931 | 0.7125 | 0.7048 | 270.763 | 267.835 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
2 x Planche CF | C24 | 32.2312 | 0.0002 | 16.1356 | 16.1356 | 0.3223 | 0.3223 | 112.809 | 112.809 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
4 x Nervure | GL24h | 8.0806 | 0.0004 | 8.5042 | 8.5043 | 0.4654 | 0.4646 | 176.867 | 176.555 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
5 x Marche | GL24h | 5.82 | 0 | 6.856 | 6.856 | 0.0532 | 0.0532 | 20.2203 | 20.2203 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Nervure | GL24h | 3.7836 | 0.0005 | 4.7442 | 4.7442 | 0.2906 | 0.2673 | 110.42 | 101.581 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
2 x Plat | Acier S235 | 2.675 | 0.0002 | 1.3208 | 1.3208 | 0.0063 | 0.0063 | 49.557 | 49.557 | Charpente metallique | Bât A Autre Bâtiment |  | R+0 | Cadwork3dProperties - Sous zone: Ruche
14 x Support allège | C24 | 3.97 | 0.0001 | 1.1573 | 1.1573 | 0.0119 | 0.0119 | 4.1685 | 4.1685 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+4
2 x Limon | Acier S235 | 3.2321 | 0.0004 | 6.9969 | 6.9969 | 0.0371 | 0.0352 | 291.531 | 276.218 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
Précadre | C24 | 2.4 | 0.0001 | 0.411 | 0.411 | 0.0036 | 0.0036 | 1.26 | 1.26 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
2 x Muraillère | GL24h | 3.62 | 0.0001 | 1.7656 | 1.7656 | 0.0507 | 0.0507 | 19.2584 | 19.2584 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
12 x Précadre | C24 | 3 | 0.0001 | 0.513 | 0.513 | 0.0045 | 0.0045 | 1.575 | 1.575 | MOB/FOB | Bât B Learning center | 2 B1 MOB 360 | R+2
Support allège | C24 | 1.0677 | 0.0001 | 0.3631 | 0.3631 | 0.0058 | 0.0058 | 2.0179 | 2.0179 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
15 x Nervure | GL24h | 8.354 | 0.0005 | 10.7559 | 10.7559 | 0.6416 | 0.6346 | 243.802 | 241.139 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
2 x Arbalétrier | GL24h | 6.4105 | 0.0007 | 10.3146 | 10.3146 | 0.8237 | 0.6948 | 313.002 | 264.026 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+4 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Arb
13 x Nervure | GL24h | 9.4378 | 0.0005 | 12.1367 | 12.1367 | 0.7248 | 0.7172 | 275.433 | 272.53 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
2 x Suspente | Acier S235 | 1.3521 | 0 | 0.371 | 0.371 | 0.0008 | 0.0007 | 5.9085 | 5.803 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche; PredefinedType: STUD
Diagonale | GL24h | 3.8134 | 0.0002 | 2.7414 | 2.7414 | 0.1236 | 0.1206 | 46.9501 | 45.8137 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Diag
4 x Précadre | C24 | 2.86 | 0.0001 | 0.6623 | 0.6623 | 0.0064 | 0.0064 | 2.2523 | 2.2523 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2 | PredefinedType: STUD
2 x Limon | Acier S235 | 0.1955 | 0.0003 | 0.2771 | 0.2771 | 0.0011 | 0.0008 | 8.4252 | 6.6281 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
4 x Précadre | C24 | 2.86 | 0.0001 | 0.6623 | 0.6623 | 0.0064 | 0.0064 | 2.2523 | 2.2523 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1 | PredefinedType: STUD
2 x Limon | Acier S235 | 5.462 | 0.0003 | 9.1583 | 9.1583 | 0.03 | 0.029 | 235.411 | 227.891 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
4 x Muraillère | GL24h | 1.95 | 0.0001 | 0.964 | 0.964 | 0.0273 | 0.0273 | 10.374 | 10.374 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Muraillère | GL24h | 23.36 | 0.0002 | 12.1792 | 12.1792 | 0.3738 | 0.3738 | 142.029 | 142.029 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
Lièrne BLC | GL24h | 7.765 | 0.0002 | 5.3362 | 5.3362 | 0.2174 | 0.2174 | 82.6193 | 82.6193 | Charpente L.C. | Bât A Autre Bâtiment | A1 Hall | R+1 | Cadwork3dProperties - Nom export 2d: Li
Limon | Acier S235 | 3.4877 | 0.0004 | 7.471 | 7.471 | 0.0401 | 0.0375 | 314.588 | 294.676 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
2 x Limon | Acier S235 | 5.0569 | 0.0003 | 8.4276 | 8.4276 | 0.0278 | 0.0267 | 217.954 | 209.619 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
Traverse | Acier S235 | 2.435 | 0.0002 | 2.8069 | 2.8069 | 0.0056 | 0.0056 | 43.5865 | 44.3239 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Tra
2 x Planche CF | C24 | 23.28 | 0.0002 | 13.5264 | 13.5264 | 0.2794 | 0.2794 | 97.776 | 97.776 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+1
2 x Diagonale | GL24h | 3.4991 | 0.0002 | 2.5068 | 2.5068 | 0.1134 | 0.1097 | 43.0807 | 41.6952 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+3 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Diag
2 x Plat | Acier S235 | 3.0067 | 0 | 0.5179 | 0.5179 | 0.0014 | 0.0014 | 11.3354 | 11.3227 | Escalier | Bât A Autre Bâtiment |  | R+2 | Cadwork3dProperties - Sous zone: Ruche
8 x Muraillère | GL24h | 2.23 | 0.0001 | 1.0984 | 1.0984 | 0.0312 | 0.0312 | 11.8636 | 11.8636 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Support allège | C24 | 1.0675 | 0.0001 | 0.3631 | 0.3631 | 0.0058 | 0.0058 | 2.0175 | 2.0175 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
8 x Lièrne BLC | GL24h | 3.76 | 0.0002 | 2.6128 | 2.6128 | 0.1053 | 0.1053 | 40.0064 | 40.0064 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Li
2 x Muraillère | GL24h | 2.175 | 0.0002 | 1.163 | 1.163 | 0.0348 | 0.0348 | 13.224 | 13.224 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Muraillère | GL24h | 1.95 | 0.0001 | 0.964 | 0.964 | 0.0273 | 0.0273 | 10.374 | 10.374 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Muraillère | GL24h | 23.28 | 0.0002 | 12.1376 | 12.1376 | 0.3725 | 0.3725 | 141.542 | 141.542 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
2 x Muraillère | GL24h | 2.37 | 0.0002 | 1.2644 | 1.2644 | 0.0379 | 0.0379 | 14.4096 | 14.4096 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Muraillère | GL24h | 23.28 | 0.0002 | 12.1376 | 12.1376 | 0.3725 | 0.3725 | 141.542 | 141.542 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
2 x Planche CF | C24 | 15.48 | 0.0002 | 7.76 | 7.76 | 0.1548 | 0.1548 | 54.18 | 54.18 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+1
12 x Poteau | GL24h | 3.24 | 0.0002 | 2.3976 | 2.3976 | 0.105 | 0.105 | 39.8909 | 39.8909 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+3 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
2 x Muraillère | GL24h | 8.1 | 0.0002 | 4.244 | 4.244 | 0.1296 | 0.1296 | 49.248 | 49.248 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Planche CF | C24 | 34.75 | 0.0002 | 17.395 | 17.395 | 0.3475 | 0.3475 | 121.625 | 121.625 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+1
2 x Plat | Acier S235 | 2.154 | 0 | 0.3714 | 0.3714 | 0.001 | 0.001 | 8.1206 | 8.1163 | Escalier | Bât A Autre Bâtiment |  | R+2 | Cadwork3dProperties - Sous zone: Ruche
Planche CF | C24 | 34.75 | 0.0002 | 20.179 | 20.179 | 0.417 | 0.417 | 145.95 | 145.95 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+1
Précadre | C24 | 2.4 | 0.0001 | 0.411 | 0.411 | 0.0036 | 0.0036 | 1.26 | 1.26 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Marche | GL24h | 2.44 | 0 | 1.2772 | 1.2772 | 0.0095 | 0.0095 | 3.6216 | 3.6216 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
4 x Muraillère | GL24h | 4.31 | 0.0001 | 2.0968 | 2.0968 | 0.0603 | 0.0603 | 22.9292 | 22.9292 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
8 x Muraillère | GL24h | 3.62 | 0.0001 | 1.7656 | 1.7656 | 0.0507 | 0.0507 | 19.2584 | 19.2584 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Précadre | C24 | 1.9982 | 0.0001 | 0.3427 | 0.3427 | 0.003 | 0.003 | 1.0491 | 1.0491 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Planche CF | C24 | 22.3479 | 0.0002 | 11.1697 | 11.1697 | 0.2235 | 0.223 | 78.2175 | 78.0393 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
4 x Précadre | C24 | 2.86 | 0.0001 | 0.6623 | 0.6623 | 0.0064 | 0.0064 | 2.2523 | 2.2523 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3 | PredefinedType: STUD
3 x Support allège | C24 | 2.16 | 0.0001 | 0.7236 | 0.7236 | 0.0117 | 0.0117 | 4.0824 | 4.0824 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Contre marche | GL24h | 4.2424 | 0 | 6.2251 | 6.2251 | 0.1482 | 0.0483 | 56.3337 | 18.3589 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Lièrne BLC | GL24h | 10.1111 | 0.0002 | 6.9315 | 6.9315 | 0.2831 | 0.2831 | 107.582 | 107.582 | Charpente L.C. | Bât A Autre Bâtiment | A1 Hall | R+0 | Cadwork3dProperties - Nom export 2d: Li
Lièrne BLC | GL24h | 22.3636 | 0.0002 | 15.2425 | 15.2425 | 0.6262 | 0.6252 | 237.949 | 237.57 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Nom export 2d: Li
2 x Muraillère | GL24h | 4.31 | 0.0001 | 2.0968 | 2.0968 | 0.0603 | 0.0603 | 22.9292 | 22.9292 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Nervure | GL24h | 1.84 | 0.0005 | 2.5088 | 2.5088 | 0.1413 | 0.1413 | 53.6986 | 53.6986 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Lièrne BLC | GL24h | 18.3553 | 0.0002 | 12.5168 | 12.5168 | 0.5139 | 0.513 | 195.301 | 194.922 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Nom export 2d: Li
Lièrne BLC | GL24h | 8.755 | 0.0002 | 5.9678 | 5.9678 | 0.2451 | 0.2431 | 93.1531 | 92.3954 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Nom export 2d: Li
Planche CF | C24 | 21.5748 | 0.0002 | 10.7832 | 10.7832 | 0.2157 | 0.2152 | 75.5118 | 75.3337 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
2 x Planche CF | C24 | 15.48 | 0.0002 | 7.76 | 7.76 | 0.1548 | 0.1548 | 54.18 | 54.18 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+2
Lièrne BLC | GL24h | 8.755 | 0.0002 | 5.9678 | 5.9678 | 0.2451 | 0.2431 | 93.153 | 92.3953 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Nom export 2d: Li
VOLEE-065 | Béton | 2.0606 | 0.0014 | 7.9296 | 7.9296 | 0.8609 | 0.621 | 2066.06 | 1490.47 | Béton maquette archi |  | 0 STR BETON
4 x Précadre | C24 | 1.98 | 0.0001 | 0.3396 | 0.3396 | 0.003 | 0.003 | 1.0395 | 1.0395 | MOB/FOB | Bât B Learning center | 2 B1 MOB 360 | R+2
2 x Muraillère | GL24h | 34.77 | 0.0002 | 18.1124 | 18.1124 | 0.5563 | 0.5563 | 211.402 | 211.402 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
4 x Nervure | GL24h | 8.0787 | 0.0005 | 10.4754 | 10.4754 | 0.6204 | 0.6193 | 235.77 | 235.336 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
4 x Précadre | C24 | 0.9399 | 0.0001 | 0.1628 | 0.1628 | 0.0014 | 0.0014 | 0.4934 | 0.4934 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Planche CF | C24 | 34.75 | 0.0002 | 20.179 | 20.179 | 0.417 | 0.417 | 145.95 | 145.95 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+2
Planche CF | C24 | 15.48 | 0.0002 | 9.0024 | 9.0024 | 0.1858 | 0.1858 | 65.016 | 65.016 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+1
Lièrne BLC | GL24h | 7.73 | 0.0002 | 5.3124 | 5.3124 | 0.2164 | 0.2164 | 82.2472 | 82.2472 | Charpente L.C. | Bât A Autre Bâtiment | A1 Hall | R+1 | Cadwork3dProperties - Nom export 2d: Li
MOBILIER-0027 | Béton | 13.8659 | 0.005 | 145.863 | 145.863 | 13.8659 | 13.8299 | 33278.2 | 33191.8 | Béton maquette archi |  | 0 STR BETON
Poteau | GL24h | 2.41 | 0.0002 | 2.2176 | 2.2176 | 0.1166 | 0.1166 | 44.3247 | 44.3247 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
6 x Lièrne BLC | GL24h | 3.78 | 0.0002 | 2.6264 | 2.6264 | 0.1058 | 0.1058 | 40.2192 | 40.2192 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Li
2 x Planche CF | C24 | 34.75 | 0.0002 | 17.395 | 17.395 | 0.3475 | 0.3475 | 121.625 | 121.625 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+2
Marche | GL24h | 2.1 | 0 | 9.1148 | 9.1148 | 0.0718 | 0.0718 | 27.2966 | 27.2966 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche
Marche | GL24h | 2.1 | 0 | 1.2945 | 1.2945 | 0.0097 | 0.0097 | 3.7027 | 3.7027 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche
2 x Précadre | C24 | 0.95 | 0.0001 | 0.1645 | 0.1645 | 0.0014 | 0.0014 | 0.4988 | 0.4988 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
Précadre | C24 | 1.9982 | 0.0001 | 0.3427 | 0.3427 | 0.003 | 0.003 | 1.0491 | 1.0491 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
Marche | GL24h | 2.1 | 0 | 0.328 | 0.328 | 0.0021 | 0.0021 | 0.7869 | 0.7869 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche
Nervure | GL24h | 3.2751 | 0.0005 | 4.1099 | 4.1099 | 0.2515 | 0.2296 | 95.5798 | 87.23 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
2 x Limon | GL24h | 4.0443 | 0.0003 | 4.0178 | 4.0178 | 0.2588 | 0.2346 | 98.357 | 89.142 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
Marche | GL24h | 2.1 | 0 | 1.3199 | 1.3199 | 0.0099 | 0.0099 | 3.7793 | 3.7793 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche
Muraillère | GL24h | 2.39 | 0.0002 | 1.2748 | 1.2748 | 0.0382 | 0.0382 | 14.5312 | 14.5312 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
Muraillère | GL24h | 26.6672 | 0.0002 | 13.8877 | 13.8877 | 0.4267 | 0.4263 | 162.137 | 161.982 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
Béton | Béton | 4.8602 | 0.0048 | 50.6842 | 50.6842 | 4.7133 | 4.6784 | 11311.9 | 11228.1 | Béton maquette archi |  | 0 STR BETON
Poutre | GL24h | 2.6024 | 0.0004 | 3.2824 | 3.2824 | 0.2248 | 0.2239 | 85.4419 | 85.0757 | Charpente L.C. | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Lièrne BLC | GL24h | 3.55 | 0.0002 | 2.47 | 2.47 | 0.0994 | 0.0994 | 37.772 | 37.772 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Li
Muraillère sur beton | GL24h | 3.953 | 0.0002 | 2.744 | 2.744 | 0.1107 | 0.1107 | 42.0599 | 42.0599 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Muraillère sur beton | GL24h | 0.987 | 0.0002 | 0.7272 | 0.7272 | 0.0276 | 0.0276 | 10.5017 | 10.5017 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Muraillère sur beton | GL24h | 17.895 | 0.0002 | 12.2246 | 12.2246 | 0.5011 | 0.5011 | 190.403 | 190.403 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration; Nom export 2d: Mu
Muraillère | GL24h | 2.435 | 0.0002 | 1.2982 | 1.2982 | 0.039 | 0.039 | 14.8048 | 14.8048 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
6 x Lièrne BLC | GL24h | 3.78 | 0.0002 | 2.6264 | 2.6264 | 0.1058 | 0.1058 | 40.2192 | 40.2192 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Li
Muraillère | GL24h | 18.8892 | 0.0002 | 9.8431 | 9.8431 | 0.3022 | 0.3018 | 114.846 | 114.692 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
2 x Muraillère | GL24h | 8.1 | 0.0002 | 4.244 | 4.244 | 0.1296 | 0.1296 | 49.248 | 49.248 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
3 x Nervure | GL24h | 8.2266 | 0.0005 | 10.7067 | 10.7067 | 0.6318 | 0.6306 | 240.085 | 239.643 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
8 x Arêtier | GL24h | 5.2975 | 0.0003 | 4.7491 | 4.7491 | 0.267 | 0.2495 | 101.458 | 94.8055 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+4 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Arb
Muraillère sur beton | GL24h | 4.08 | 0.0002 | 2.8304 | 2.8304 | 0.1142 | 0.1142 | 43.4112 | 43.4112 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Nom export 2d: Mu
2 x Muraillère | GL24h | 8.0733 | 0.0002 | 4.2267 | 4.2267 | 0.1292 | 0.1291 | 49.0858 | 49.0459 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
Planche CF | C24 | 28.0052 | 0.0002 | 16.2331 | 16.2331 | 0.3361 | 0.3353 | 117.622 | 117.365 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Planche CF | C24 | 28.1273 | 0.0002 | 16.3039 | 16.3039 | 0.3375 | 0.3368 | 118.135 | 117.878 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Planche CF | C24 | 26.525 | 0.0002 | 15.3746 | 15.3746 | 0.3183 | 0.3176 | 111.405 | 111.149 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Planche CF | C24 | 26.6471 | 0.0002 | 15.4454 | 15.4454 | 0.3198 | 0.319 | 111.918 | 111.661 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Planche CF | C24 | 22.4497 | 0.0002 | 11.2206 | 11.2206 | 0.2245 | 0.224 | 78.5739 | 78.3957 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
2 x Muraillère | GL24h | 34.77 | 0.0002 | 18.1124 | 18.1124 | 0.5563 | 0.5563 | 211.402 | 211.402 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
2 x Muraillère | GL24h | 3.7535 | 0.0002 | 1.9823 | 1.9823 | 0.0601 | 0.06 | 22.8212 | 22.8037 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
MOBILIER-0027 | Béton | 8.5331 | 0.0085 | 98.8643 | 98.8643 | 31.2808 | 6.9485 | 75073.9 | 16676.4 | Béton maquette archi |  | 0 STR BETON
M_Ext-017 | Béton | 2.5 | 0.0002 | 1.331 | 1.331 | 0.0306 | 0.0306 | 73.5584 | 73.5584 | Béton maquette archi |  | 0 STR BETON | PredefinedType: STUD
2 x Lièrne BLC | GL24h | 3.55 | 0.0002 | 2.47 | 2.47 | 0.0994 | 0.0994 | 37.772 | 37.772 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Li
2 x Muraillère | GL24h | 4.845 | 0.0001 | 2.3536 | 2.3536 | 0.0678 | 0.0678 | 25.7754 | 25.7754 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Lièrne BLC | GL24h | 2.6886 | 0.0002 | 1.8495 | 1.8495 | 0.0753 | 0.0723 | 28.6066 | 27.4712 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Li
Nervure | GL24h | 1.79 | 0.0004 | 1.9768 | 1.9768 | 0.1031 | 0.1031 | 39.1795 | 39.1795 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
Lièrne BLC | GL24h | 3.605 | 0.0002 | 2.5074 | 2.5074 | 0.1009 | 0.1009 | 38.3575 | 38.3575 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Li
2 x Plat | Acier S235 | 1.9323 | 0 | 0.3333 | 0.3333 | 0.0009 | 0.0009 | 7.2849 | 7.281 | Escalier | Bât A Autre Bâtiment |  | R+2 | Cadwork3dProperties - Sous zone: Ruche
2 x Muraillère | GL24h | 2.23 | 0.0001 | 1.0984 | 1.0984 | 0.0312 | 0.0312 | 11.8636 | 11.8636 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Précadre | C24 | 1.9982 | 0.0001 | 0.3427 | 0.3427 | 0.003 | 0.003 | 1.0491 | 1.0491 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
Muraillère | GL24h | 8.1138 | 0.0003 | 6.8713 | 6.8713 | 0.2596 | 0.2593 | 98.6638 | 98.5433 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
Muraillère | GL24h | 8.1127 | 0.0002 | 4.2473 | 4.2473 | 0.1298 | 0.1297 | 49.325 | 49.2865 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
Muraillère | GL24h | 1.9959 | 0.0002 | 1.0673 | 1.0673 | 0.0319 | 0.0319 | 12.1351 | 12.105 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Mu
Muraillère | GL24h | 0.844 | 0.0001 | 0.4331 | 0.4331 | 0.0118 | 0.0118 | 4.4901 | 4.4901 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Lièrne BLC | GL24h | 8.755 | 0.0002 | 5.9678 | 5.9678 | 0.2451 | 0.2431 | 93.1531 | 92.3954 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+1 | Cadwork3dProperties - Nom export 2d: Li
Limon | Acier S235 | 0.1903 | 0.0001 | 0.0197 | 0.0197 | 0.0022 | 0.0001 | 17.1656 | 0.5954 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Lim
3 x Plat | Acier S235 | 5.42 | 0.0002 | 2.6714 | 2.6714 | 0.0128 | 0.0128 | 100.411 | 100.411 | Charpente metallique | Bât A Autre Bâtiment |  | R+0 | Cadwork3dProperties - Sous zone: Ruche
MOBILIER-0027 | Béton | 18.0252 | 0.005 | 188.158 | 188.158 | 18.0252 | 17.4516 | 43260.4 | 41883.9 | Béton maquette archi |  | 0 STR BETON
MOBILIER-0027 | Béton | 11.3465 | 0.005 | 119.661 | 119.661 | 11.3465 | 11.3105 | 27231.6 | 27145.2 | Béton maquette archi |  | 0 STR BETON
VOLEE-021 | Béton | 6.418 | 0.0016 | 24.9391 | 24.9391 | 11.2875 | 2.0802 | 27090 | 4992.55 | Béton maquette archi |  | 0 STR BETON
2 x Planche CF | C24 | 7.86 | 0.0002 | 3.95 | 3.95 | 0.0786 | 0.0786 | 27.51 | 27.51 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
VOLEE-064 | Béton | 2.2874 | 0.0014 | 8.5353 | 8.5353 | 0.9556 | 0.6455 | 2293.39 | 1549.12 | Béton maquette archi |  | 0 STR BETON
VOLEE-064 | Béton | 2.2629 | 0.0014 | 8.4143 | 8.4143 | 0.9324 | 0.6317 | 2237.83 | 1516.18 | Béton maquette archi |  | 0 STR BETON
VOLEE-035 | Béton | 2.3656 | 0.0014 | 8.7361 | 8.7361 | 0.9718 | 0.6586 | 2332.44 | 1580.62 | Béton maquette archi |  | 0 STR BETON
MOBILIER-0027 | Béton | 13.8659 | 0.005 | 145.863 | 145.863 | 13.8659 | 13.8299 | 33278 | 33191.6 | Béton maquette archi |  | 0 STR BETON
VOLEE-020 | Béton | 4.6438 | 0.0014 | 17.5758 | 17.5758 | 1.8985 | 1.4111 | 4556.51 | 3386.63 | Béton maquette archi |  | 0 STR BETON
VOLEE-065 | Béton | 3.6716 | 0.0014 | 13.9789 | 13.9789 | 1.513 | 1.1172 | 3631.17 | 2681.23 | Béton maquette archi |  | 0 STR BETON
2 x Muraillère | GL24h | 3.7116 | 0.0002 | 1.9613 | 1.9613 | 0.0594 | 0.0594 | 22.5664 | 22.5576 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
Lièrne BLC | GL24h | 13.555 | 0.0002 | 9.2734 | 9.2734 | 0.3795 | 0.3795 | 144.225 | 144.225 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration; Nom export 2d: Li
6 x Muraillère | GL24h | 8.06 | 0.0002 | 4.2232 | 4.2232 | 0.129 | 0.129 | 49.0048 | 49.0048 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
2 x Muraillère | GL24h | 2.39 | 0.0002 | 1.2748 | 1.2748 | 0.0382 | 0.0382 | 14.5312 | 14.5312 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
Muraillère | GL24h | 3.92 | 0.0002 | 2.0704 | 2.0704 | 0.0627 | 0.0627 | 23.8336 | 23.8336 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
2 x Support allège | C24 | 1.13 | 0.0001 | 0.3837 | 0.3837 | 0.0061 | 0.0061 | 2.1357 | 2.1357 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
2 x Plat | Acier S235 | 8.06 | 0.0002 | 4.1074 | 4.1074 | 0.0197 | 0.0197 | 154.698 | 154.698 | Charpente metallique | Bât B Learning center |  | R+2
Muraillère | GL24h | 9.1556 | 0.0002 | 4.7929 | 4.7929 | 0.1465 | 0.1465 | 55.6663 | 55.6663 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+0 | Cadwork3dProperties - Nom export 2d: Mu
4 x Support allège | C24 | 1.1199 | 0.0001 | 0.3803 | 0.3804 | 0.006 | 0.006 | 2.1165 | 2.1165 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Muraillère | GL24h | 8.1138 | 0.0003 | 6.8713 | 6.8713 | 0.2596 | 0.2593 | 98.6638 | 98.5433 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Muraillère | GL24h | 8.06 | 0.0002 | 4.2232 | 4.2232 | 0.129 | 0.129 | 49.0048 | 49.0048 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
2 x Limon | GL24h | 6.51 | 0.0004 | 6.8706 | 6.8706 | 0.4218 | 0.4021 | 160.303 | 152.802 | Escalier | Bât B Learning center | 2 C1 Escalier | R+1 | Cadwork3dProperties - Nom export 2d: Lim
Contre marche | GL24h | 1.88 | 0 | 2.0628 | 2.0628 | 0.0331 | 0.0157 | 12.5734 | 5.9809 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Poutre acrotère | GL24h | 9.6099 | 0.0012 | 24.8627 | 24.8627 | 2.2288 | 2.0597 | 846.938 | 782.674 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration; Nom export 2d: Pr
Nervure | GL24h | 5.7587 | 0.0005 | 7.3075 | 7.3075 | 0.4423 | 0.4219 | 168.062 | 160.331 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Muraillère | GL24h | 1.99 | 0.0002 | 1.0668 | 1.0668 | 0.0318 | 0.0318 | 12.0992 | 12.0992 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
Muraillère | GL24h | 4.1169 | 0.0002 | 2.1708 | 2.1708 | 0.0659 | 0.0658 | 25.0415 | 25.0113 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+3 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Muraillère | GL24h | 2.3961 | 0.0002 | 1.2754 | 1.2754 | 0.0383 | 0.0383 | 14.5683 | 14.5382 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
Muraillère | GL24h | 4.177 | 0.0002 | 2.2015 | 2.2015 | 0.0668 | 0.0668 | 25.3959 | 25.3658 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+3 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Poutre | GL24h | 3.9348 | 0.0004 | 4.8798 | 4.8798 | 0.34 | 0.3389 | 129.187 | 128.798 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Muraillère | GL24h | 4.177 | 0.0002 | 2.202 | 2.202 | 0.0669 | 0.0668 | 25.4066 | 25.3764 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+3 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Nervure | GL24h | 6.6194 | 0.0004 | 6.9847 | 6.9847 | 0.3813 | 0.3805 | 144.886 | 144.574 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
Muraillère sur beton | GL24h | 2.28 | 0.0002 | 1.6064 | 1.6064 | 0.0638 | 0.0638 | 24.2592 | 24.2592 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Muraillère | GL24h | 8.14 | 0.0002 | 4.2648 | 4.2648 | 0.1302 | 0.1302 | 49.4912 | 49.4912 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Nervure | GL24h | 1.816 | 0.0005 | 2.2257 | 2.2257 | 0.1395 | 0.1162 | 52.998 | 44.1588 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Muraillère sur beton | GL24h | 8.14 | 0.0002 | 5.5912 | 5.5912 | 0.2279 | 0.2279 | 86.6096 | 86.6096 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Poteau | GL24h | 2.62 | 0.0002 | 1.9512 | 1.9512 | 0.0849 | 0.0849 | 32.2574 | 32.2574 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
Nervure | GL24h | 7.7188 | 0.0005 | 9.7812 | 9.7812 | 0.5928 | 0.5695 | 225.264 | 216.425 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Muraillère | GL24h | 2.7323 | 0.0002 | 1.4302 | 1.4302 | 0.0437 | 0.0429 | 16.6123 | 16.3031 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
2 x Muraillère | GL24h | 8.06 | 0.0002 | 4.2232 | 4.2232 | 0.129 | 0.129 | 49.0048 | 49.0048 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Nervure | GL24h | 7.2088 | 0.0005 | 9.1452 | 9.1452 | 0.5536 | 0.5317 | 210.383 | 202.034 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Poutre | GL24h | 8.0815 | 0.0004 | 9.8531 | 9.8531 | 0.6982 | 0.697 | 265.332 | 264.848 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Pr
2 x Lièrne BLC | GL24h | 15.79 | 0.0002 | 10.7932 | 10.7932 | 0.4421 | 0.4421 | 168.006 | 168.006 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+1 | Cadwork3dProperties - Nom export 2d: Li
Lièrne BLC | GL24h | 32.1761 | 0.0002 | 21.9149 | 21.9149 | 0.9009 | 0.8999 | 342.353 | 341.974 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+1 | Cadwork3dProperties - Nom export 2d: Li
Lièrne BLC | GL24h | 28.1678 | 0.0002 | 19.1893 | 19.1893 | 0.7887 | 0.7877 | 299.705 | 299.327 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+1 | Cadwork3dProperties - Nom export 2d: Li
Marche | GL24h | 3.94 | 0 | 3.3687 | 3.3687 | 0.0258 | 0.0258 | 9.8176 | 9.8176 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Poutre | GL24h | 2.6024 | 0.0004 | 3.2824 | 3.2824 | 0.2248 | 0.2239 | 85.4419 | 85.0757 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Pr
4 x Support allège | C24 | 1.1199 | 0.0001 | 0.3803 | 0.3804 | 0.006 | 0.006 | 2.1165 | 2.1165 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
2 x Précadre | C24 | 0.8877 | 0.0001 | 0.1539 | 0.1539 | 0.0013 | 0.0013 | 0.466 | 0.466 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Muraillère | GL24h | 2.665 | 0.0002 | 1.4178 | 1.4178 | 0.0426 | 0.0426 | 16.2032 | 16.2032 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Muraillère | GL24h | 8.0688 | 0.0002 | 4.2252 | 4.2252 | 0.1291 | 0.129 | 49.0585 | 49.0283 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Mu
2 x Précadre | C24 | 0.95 | 0.0001 | 0.1645 | 0.1645 | 0.0014 | 0.0014 | 0.4988 | 0.4988 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+3
Précadre | C24 | 1.98 | 0.0001 | 0.3396 | 0.3396 | 0.003 | 0.003 | 1.0395 | 1.0395 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
2 x Muraillère | GL24h | 8.28 | 0.0002 | 4.3376 | 4.3376 | 0.1325 | 0.1325 | 50.3424 | 50.3424 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+2 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Nervure | GL24h | 1.3082 | 0.0005 | 1.5923 | 1.5923 | 0.1005 | 0.0785 | 38.1783 | 29.8279 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Nervure | GL24h | 8.2139 | 0.0005 | 10.6102 | 10.6102 | 0.6308 | 0.6266 | 239.714 | 238.092 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
2 x Muraillère | GL24h | 8.28 | 0.0002 | 4.3376 | 4.3376 | 0.1325 | 0.1325 | 50.3424 | 50.3424 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
Nervure | GL24h | 5.242 | 0.0005 | 6.6275 | 6.6275 | 0.4026 | 0.3806 | 152.981 | 144.632 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Marche | GL24h | 2.1 | 0 | 1.3199 | 1.3199 | 0.0099 | 0.0099 | 3.7793 | 3.7793 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche
Poteau | GL24h | 2.074 | 0.0002 | 1.5581 | 1.5581 | 0.0672 | 0.0672 | 25.5351 | 25.5351 | Charpente L.C. | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Pt; PredefinedType: STUD
Lièrne BLC | GL24h | 4.5653 | 0.0002 | 3.1396 | 3.1396 | 0.1278 | 0.1268 | 48.5752 | 48.1964 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+1 | Cadwork3dProperties - Nom export 2d: Li
Lièrne BLC | GL24h | 8.5736 | 0.0002 | 5.8653 | 5.8653 | 0.2401 | 0.2391 | 91.2232 | 90.8443 | Charpente L.C. | Bât B Learning center | 2 A1 Préau | R+1 | Cadwork3dProperties - Nom export 2d: Li
Planche CF | C24 | 15.48 | 0.0002 | 9.0024 | 9.0024 | 0.1858 | 0.1858 | 65.016 | 65.016 | Charpente B.M. | Bât A Autre Bâtiment | 2 A3 Plancher CLT nervuré | R+2
Muraillère | GL24h | 4.1169 | 0.0002 | 2.1702 | 2.1702 | 0.0659 | 0.0658 | 25.031 | 25.0008 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+3 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Plat | Acier S235 | 8.06 | 0.0002 | 4.1539 | 4.1539 | 0.0199 | 0.0199 | 156.519 | 156.519 | Charpente metallique | Bât B Learning center |  | R+2
Poutre | GL24h | 8.0806 | 0.0004 | 9.8525 | 9.8525 | 0.6982 | 0.6969 | 265.301 | 264.833 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Lièrne BLC | GL24h | 4.1314 | 0.0002 | 2.8446 | 2.8446 | 0.1157 | 0.1147 | 43.9585 | 43.5793 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+2 | Cadwork3dProperties - Nom export 2d: Li
Muraillère | GL24h | 27.9338 | 0.0002 | 14.5463 | 14.5463 | 0.4469 | 0.4465 | 169.838 | 169.683 | Charpente L.C. | Bât B Learning center | 2 A2 Salles | R+1 | Cadwork3dProperties - Nom export 2d: Mu
Poutre | GL24h | 3.9178 | 0.0004 | 4.8568 | 4.8568 | 0.3385 | 0.3372 | 128.628 | 128.152 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Support allège | C24 | 1.0675 | 0.0001 | 0.3631 | 0.3631 | 0.0058 | 0.0058 | 2.0175 | 2.0175 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
2 x Support allège | C24 | 1.0677 | 0.0001 | 0.3631 | 0.3631 | 0.0058 | 0.0058 | 2.0179 | 2.0179 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+1
Support allège | C24 | 1.0677 | 0.0001 | 0.3631 | 0.3631 | 0.0058 | 0.0058 | 2.0179 | 2.0179 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
Marche | GL24h | 2.1 | 0 | 0.8713 | 0.8713 | 0.0064 | 0.0064 | 2.4259 | 2.4259 | Escalier | Bât A Autre Bâtiment | C1 Escalier | R+0 | Cadwork3dProperties - Sous zone: Ruche
Poutre | GL24h | 2.2022 | 0.0004 | 2.8021 | 2.8021 | 0.1903 | 0.1893 | 72.3028 | 71.9366 | Charpente L.C. | Bât A Autre Bâtiment | A2 Salles | R+3 | Cadwork3dProperties - Nom export 2d: Pr
Planche CF | C24 | 9.0171 | 0.0001 | 3.2571 | 3.2571 | 0.0505 | 0.0505 | 17.6735 | 17.6721 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Planche CF | C24 | 9.2746 | 0.0001 | 3.3256 | 3.3256 | 0.0519 | 0.0515 | 18.1783 | 18.0376 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Planche CF | C24 | 24.2312 | 0.0001 | 8.7344 | 8.7344 | 0.1357 | 0.1357 | 47.4932 | 47.4932 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Muraillère sur beton | GL24h | 2.39 | 0.0002 | 1.6812 | 1.6812 | 0.0669 | 0.0669 | 25.4296 | 25.4296 | Charpente L.C. | Bât A Autre Bâtiment | A3 Ruche | R+0 | Cadwork3dProperties - Nom export 2d: Mu
Planche CF | C24 | 3.0188 | 0.0001 | 1.0854 | 1.0854 | 0.0169 | 0.0167 | 5.9168 | 5.8448 | Charpente B.M. | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2

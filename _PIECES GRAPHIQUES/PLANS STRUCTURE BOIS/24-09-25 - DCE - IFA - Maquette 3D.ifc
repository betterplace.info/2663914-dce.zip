Properties of the parts of a building model (IFC4), part 4 of 4

# IfcMember (1220)
Name | Material | Length (m) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | NetSurfaceArea (m2) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg) | Group | Bâtiment | Repérage ensemble | Niveaux
Support allège | C24 | 2.16 | 0.0001 | 0.7236 | 0.7236 | 0.0117 | 0.0117 | 4.0824 | 4.0824 | MOB/FOB | Bât A Autre Bâtiment | 2 B1 MOB 360 | R+2
Muraillère | GL24h | 2.456 | 0.0001 | 1.2069 | 1.2069 | 0.0344 | 0.0344 | 13.0659 | 13.0659 | Charpente L.C. | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche; Nom export 2d: Mu
2 x Muraillère | GL24h | 9.7911 | 0.0002 | 5.1234 | 5.1234 | 0.1567 | 0.1567 | 59.5297 | 59.5297 | Charpente L.C. | Bât A Autre Bâtiment | A1 Hall | R+0 | Cadwork3dProperties - Nom export 2d: Mu
Lièrne BLC | GL24h | 9.7911 | 0.0002 | 6.7139 | 6.7139 | 0.2742 | 0.2742 | 104.177 | 104.177 | Charpente L.C. | Bât A Autre Bâtiment | A1 Hall | R+0 | Cadwork3dProperties - Nom export 2d: Li

# IfcMember: Column (6)
In: Storey 1
PredefinedType: USERDEFINED; Material: GL24h
BaseQuantities - CrossSectionArea: 0.0002 m2
Cadwork3dProperties - Group: Charpente L.C.; Bâtiment: Bât A Autre Bâtiment; Repérage ensemble: A6 Bulles; Nom export 2d: Pt; Niveaux: R+3
Name | Length (m) | OuterSurfaceArea (m2) = NetSurfaceArea (m2) | GrossVolume (m3) = NetVolume (m3) | GrossWeight (kg) = NetWeight (kg)
4 x Fourrure | 3.24 | 1.9872 | 0.07 | 26.5939
2 x Fourrure | 3.3 | 2.0232 | 0.0713 | 27.0864

# IfcPlate (70)
In: Storey 1
Material: CLT
Name | Width (m) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg) | Group | Bâtiment | Repérage ensemble | Niveaux
Plancher CLT | 10.1111 | 10.3133 | 10.3133 | 5156.65 | 5156.65 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+0
Plancher CLT | 4.845 | 1.3223 | 1.3223 | 661.16 | 661.16 | Plancher CLT | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 3.53 | 1.7143 | 1.5406 | 857.155 | 770.312 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+0 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 1.357 | 0.2752 | 0.2752 | 137.599 | 137.599 | Plancher CLT | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Plancher CLT | 35.23 | 35.2582 | 35.2582 | 17629.1 | 17629.1 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+2
Plancher CLT | 15.72 | 15.7326 | 15.7326 | 7866.29 | 7866.29 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+1
Plancher CLT | 23.66 | 7.8504 | 7.6802 | 3925.19 | 3840.09 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+2
2 x Plancher CLT | 8.32 | 5.2757 | 5.2738 | 2637.87 | 2636.92 | Plancher CLT | Bât B Learning center | 2 A4 Plancher CLT | R+2
Plancher CLT | 23.66 | 7.8504 | 7.8504 | 3925.19 | 3925.19 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+1
2 x Plancher CLT | 8.32 | 5.0061 | 5.0042 | 2503.06 | 2502.1 | Plancher CLT | Bât B Learning center | 2 A4 Plancher CLT | R+2
Plancher CLT | 28.5942 | 11.6493 | 11.3478 | 5824.64 | 5673.88 | Plancher CLT | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0
Plancher CLT | 5.42 | 1.5447 | 1.5447 | 772.35 | 772.35 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+0 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 4.31 | 1.112 | 1.112 | 555.99 | 555.99 | Plancher CLT | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 15.72 | 15.7326 | 15.7326 | 7866.29 | 7866.29 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+2
Plancher CLT | 28.2352 | 11.503 | 11.1905 | 5751.51 | 5595.25 | Plancher CLT | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Plancher CLT | 16.01 | 15.7154 | 15.7154 | 7857.71 | 7857.71 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Plancher CLT | 4.3351 | 1.3292 | 1.3285 | 664.578 | 664.245 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+3 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 8.06 | 2.9952 | 2.9952 | 1497.6 | 1497.6 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+2 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 4.053 | 1.301 | 1.301 | 650.506 | 650.506 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+0 | Cadwork3dProperties - Sous zone: Ruche
2 x Plancher CLT | 23.52 | 23.5388 | 23.5388 | 11769.4 | 11769.4 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+1
Mur CLT | 2.064 | 0.1718 | 0.1718 | 85.9243 | 85.9243 | Murs CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 24.4184 | 24.4605 | 22.3935 | 12230.3 | 11196.7 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Plancher CLT | 32.3961 | 31.8 | 29.7578 | 15900 | 14878.9 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Plancher CLT | 4.31 | 1.112 | 1.112 | 555.99 | 555.99 | Plancher CLT | Bât A Autre Bâtiment | A6 Bulles | R+3 | Cadwork3dProperties - Sous zone: Ruche
2 x Plancher CLT | 3.62 | 1.0556 | 1.0556 | 527.796 | 527.796 | Plancher CLT | Bât A Autre Bâtiment | A6 Bulles | R+3 | Cadwork3dProperties - Sous zone: Ruche
Mur CLT | 0.756 | 0.3933 | 0.337 | 196.636 | 168.52 | Murs CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Mur CLT | 0.756 | 0.195 | 0.195 | 97.524 | 97.524 | Murs CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 8.0263 | 3.2699 | 3.2689 | 1634.96 | 1634.45 | Plancher CLT | Bât B Learning center | 2 A4 Plancher CLT | R+2
Plancher CLT | 3.0796 | 0.8922 | 0.8922 | 446.102 | 446.102 | Plancher CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 8.5 | 1.9278 | 1.9278 | 963.9 | 963.9 | Plancher CLT | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0
Plancher CLT | 10.1111 | 4.1193 | 4.1193 | 2059.63 | 2059.63 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+0
Plancher CLT | 8.655 | 8.4957 | 6.4536 | 4247.87 | 3226.79 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+1
Plancher CLT | 15.72 | 5.7001 | 5.7001 | 2850.04 | 2850.04 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+1
Plancher CLT | 9.114 | 9.2963 | 7.0912 | 4648.15 | 3545.62 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0
Mur CLT | 2.184 | 0.6395 | 0.6395 | 319.738 | 319.738 | Murs CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 15.72 | 5.7001 | 5.7001 | 2850.04 | 2850.04 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+2
Mur CLT | 1.8697 | 0.7693 | 0.446 | 384.627 | 222.994 | Murs CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 17.895 | 20.6027 | 20.5981 | 10301.4 | 10299.1 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0 | Cadwork3dProperties - Sous zone: Terasse - restauration
Plancher CLT | 4.8343 | 2.0362 | 1.8297 | 1018.11 | 914.84 | Plancher CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Mur CLT | 3.1467 | 2.2369 | 1.6609 | 1118.46 | 830.462 | Murs CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Mur CLT | 2.064 | 1.0255 | 1.0255 | 512.759 | 512.759 | Murs CLT | Bât A Autre Bâtiment | C1 Escalier | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 2.1 | 0.5273 | 0.5273 | 263.635 | 263.635 | Escalier | Bât A Autre Bâtiment | A5 Plancher CLT | R+2 | Cadwork3dProperties - Sous zone: Ruche
2 x Plancher CLT | 3.62 | 1.0556 | 1.0556 | 527.796 | 527.796 | Plancher CLT | Bât A Autre Bâtiment | A6 Bulles | R+2 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 2.665 | 0.8219 | 0.8219 | 410.943 | 410.943 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+0 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 4.31 | 1.112 | 1.112 | 555.99 | 555.99 | Plancher CLT | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 11.8 | 12.036 | 12.036 | 6018 | 6018 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0
Plancher CLT | 3.62 | 1.0556 | 1.0556 | 527.796 | 527.796 | Plancher CLT | Bât A Autre Bâtiment | A6 Bulles | R+1 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 4.3374 | 1.3298 | 1.3285 | 664.921 | 664.255 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+3 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 32.9179 | 33.5762 | 31.3712 | 16788.1 | 15685.6 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+0
Plancher CLT | 8.3 | 1.6861 | 1.6861 | 843.074 | 843.074 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+0 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 23.52 | 23.5707 | 23.4439 | 11785.3 | 11721.9 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
Plancher CLT | 19.51 | 7.0743 | 7.0743 | 3537.16 | 3537.16 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+1
Plancher CLT | 8.52 | 2.6122 | 2.6122 | 1306.12 | 1306.12 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+2 | Cadwork3dProperties - Sous zone: Ruche
Plancher CLT | 35.23 | 12.8019 | 12.7805 | 6400.97 | 6390.27 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+3
Plancher CLT | 35.23 | 35.3035 | 35.2852 | 17651.7 | 17642.6 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
Plancher CLT | 19.51 | 7.0743 | 7.0743 | 3537.16 | 3537.16 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+2
Plancher CLT | 35.23 | 35.2582 | 35.2582 | 17629.1 | 17629.1 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+1
Plancher CLT | 8.52 | 2.6122 | 2.6122 | 1306.12 | 1306.12 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+1 | Cadwork3dProperties - Sous zone: Ruche
2 x Plancher CLT | 23.52 | 23.5388 | 23.5388 | 11769.4 | 11769.4 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+2
Plancher CLT | 15.72 | 15.7471 | 15.7401 | 7873.57 | 7870.07 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
Plancher CLT | 18.7468 | 18.7886 | 16.5328 | 9394.32 | 8266.42 | Plancher CLT nervure | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2
Plancher CLT | 23.58 | 7.2474 | 7.2331 | 3623.71 | 3616.55 | Plancher CLT | Bât A Autre Bâtiment | A5 Plancher CLT | R+3
Plancher CLT | 23.52 | 23.5606 | 23.5554 | 11780.3 | 11777.7 | Plancher CLT nervure | Bât A Autre Bâtiment | A4 Plancher CLT nervuré | R+3
Plancher CLT | 20.1558 | 7.3242 | 7.073 | 3662.12 | 3536.51 | Plancher CLT | Bât B Learning center | 2 A3 Plancher CLT nervuré | R+2

# IfcPlate: Floor (34)
In: Storey 1
PredefinedType: USERDEFINED; Material: Béton
Cadwork3dProperties - Group: Béton maquette archi; Repérage ensemble: 0 STR BETON
Name | Width (m) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg)
Toit-09 | 50.8 | 705.489 | 211.853 | 1693173 | 508447
Toit-09 | 0.28 | 0.0711 | 0.0711 | 170.688 | 170.688
Toit-09 | 2.0515 | 0.3205 | 0.2572 | 769.252 | 617.339
Toit-09 | 3.5949 | 0.8987 | 0.6957 | 2156.93 | 1669.57
Toit-09 | 1.4641 | 0.6588 | 0.6536 | 1581.19 | 1568.62
Toit-09 | 2.495 | 0.4547 | 0.4547 | 1091.2 | 1091.2
2 x Toit-09 | 0.3872 | 0.0214 | 0.0213 | 51.4411 | 51.1458
2 x Toit-09 | 0.387 | 0.0293 | 0.0292 | 70.3425 | 70.0731
Toit-09 | 1.3615 | 0.6935 | 0.6935 | 1664.37 | 1664.37
Toit-09 | 4.11 | 6.7897 | 6.7897 | 16295.3 | 16295.3
Toit-09 | 6.707 | 2.8823 | 2.0242 | 6917.58 | 4857.98
Toit-09 | 1.4251 | 0.3429 | 0.3421 | 822.95 | 821.105
Toit-09 | 1.4641 | 0.6588 | 0.6569 | 1581.19 | 1576.58
Toit-09 | 1.81 | 0.607 | 0.607 | 1456.76 | 1456.76
Toit-09 | 2.495 | 0.9288 | 0.9288 | 2229 | 2229
Toit-09 | 4.35 | 7.1862 | 7.1862 | 17246.9 | 17246.9
Toit-09 | 10.805 | 50.0144 | 34.183 | 120035 | 82039.1
Toit-09 | 35.27 | 306.637 | 192.874 | 735930 | 462897
Toit-09 | 50.8 | 992.539 | 865.491 | 2382094 | 2077177
Toit-09 | 2.08 | 15.4154 | 15.4148 | 36997 | 36995.6
Toit-09 | 8.195 | 37.9316 | 37.929 | 91035.8 | 91029.6
Toit-09 | 28.0198 | 63.9573 | 29.6746 | 153497 | 71218.9
Toit-09 | 2.52 | 2.6985 | 2.6985 | 6476.43 | 6476.43
Toit-09 | 2.495 | 0.6625 | 0.6625 | 1589.95 | 1589.95
Toit-09 | 50.2 | 973.286 | 800.611 | 2335887 | 1921467
Toit-09 | 1.4251 | 0.307 | 0.3069 | 736.873 | 736.545
Toit-09 | 2.7636 | 0.7752 | 0.7752 | 1860.54 | 1860.54
Toit-09 | 4.2991 | 8.4537 | 8.4537 | 20288.9 | 20288.9
Toit-09 | 18.1296 | 234.014 | 167.223 | 561634 | 401336
Toit-09 | 13.7344 | 60.6731 | 48.6728 | 145615 | 116815
Toit-09 | 0.2511 | 1.6149 | 1.6149 | 3875.81 | 3875.81
Toit-09 | 13.587 | 100.041 | 100.041 | 240098 | 240098
